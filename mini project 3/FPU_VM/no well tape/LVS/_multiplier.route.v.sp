$ Spice netlist generated by v2lvs
$ v2020.1_25.14    Mon Feb 3 16:40:08 PST 2020
*.BUSDELIMITER [

.SUBCKT datapath__0_13 M_multiplied p_0[22] p_0[21] p_0[20] p_0[19] p_0[18]
+ p_0[17] p_0[16] p_0[15] p_0[14] p_0[13] p_0[12] p_0[11] p_0[10] p_0[9] p_0[8]
+ p_0[7] p_0[6] p_0[5] p_0[4] p_0[3] p_0[2] p_0[1] p_0[0] M_resultTruncated[22]
+ M_resultTruncated[21] M_resultTruncated[20] M_resultTruncated[19]
+ M_resultTruncated[18] M_resultTruncated[17] M_resultTruncated[16]
+ M_resultTruncated[15] M_resultTruncated[14] M_resultTruncated[13]
+ M_resultTruncated[12] M_resultTruncated[11] M_resultTruncated[10]
+ M_resultTruncated[9] M_resultTruncated[8] M_resultTruncated[7]
+ M_resultTruncated[6] M_resultTruncated[5] M_resultTruncated[4]
+ M_resultTruncated[3] M_resultTruncated[2] M_resultTruncated[1]
+ M_resultTruncated[0]
Xi_22 XOR2_X1 $PINS Z=M_resultTruncated[22] A=p_0[22] B=n_21
Xi_21 HA_X1 $PINS CO=n_21 S=M_resultTruncated[21] A=p_0[21] B=n_20
Xi_20 HA_X1 $PINS CO=n_20 S=M_resultTruncated[20] A=p_0[20] B=n_19
Xi_19 HA_X1 $PINS CO=n_19 S=M_resultTruncated[19] A=p_0[19] B=n_18
Xi_18 HA_X1 $PINS CO=n_18 S=M_resultTruncated[18] A=p_0[18] B=n_17
Xi_17 HA_X1 $PINS CO=n_17 S=M_resultTruncated[17] A=p_0[17] B=n_16
Xi_16 HA_X1 $PINS CO=n_16 S=M_resultTruncated[16] A=p_0[16] B=n_15
Xi_15 HA_X1 $PINS CO=n_15 S=M_resultTruncated[15] A=p_0[15] B=n_14
Xi_14 HA_X1 $PINS CO=n_14 S=M_resultTruncated[14] A=p_0[14] B=n_13
Xi_13 HA_X1 $PINS CO=n_13 S=M_resultTruncated[13] A=p_0[13] B=n_12
Xi_12 HA_X1 $PINS CO=n_12 S=M_resultTruncated[12] A=p_0[12] B=n_11
Xi_11 HA_X1 $PINS CO=n_11 S=M_resultTruncated[11] A=p_0[11] B=n_10
Xi_10 HA_X1 $PINS CO=n_10 S=M_resultTruncated[10] A=p_0[10] B=n_9
Xi_9 HA_X1 $PINS CO=n_9 S=M_resultTruncated[9] A=p_0[9] B=n_8
Xi_8 HA_X1 $PINS CO=n_8 S=M_resultTruncated[8] A=p_0[8] B=n_7
Xi_7 HA_X1 $PINS CO=n_7 S=M_resultTruncated[7] A=p_0[7] B=n_6
Xi_6 HA_X1 $PINS CO=n_6 S=M_resultTruncated[6] A=p_0[6] B=n_5
Xi_5 HA_X1 $PINS CO=n_5 S=M_resultTruncated[5] A=p_0[5] B=n_4
Xi_4 HA_X1 $PINS CO=n_4 S=M_resultTruncated[4] A=p_0[4] B=n_3
Xi_3 HA_X1 $PINS CO=n_3 S=M_resultTruncated[3] A=p_0[3] B=n_2
Xi_2 HA_X1 $PINS CO=n_2 S=M_resultTruncated[2] A=p_0[2] B=n_1
Xi_1 HA_X1 $PINS CO=n_1 S=M_resultTruncated[1] A=p_0[1] B=n_0
Xi_0 HA_X1 $PINS CO=n_0 S=M_resultTruncated[0] A=M_multiplied B=p_0[0]
.ENDS

.SUBCKT datapath__0_2 B_imm[31] B_imm[30] B_imm[29] B_imm[28] B_imm[27]
+ B_imm[26] B_imm[25] B_imm[24] B_imm[23] B_imm[22] B_imm[21] B_imm[20]
+ B_imm[19] B_imm[18] B_imm[17] B_imm[16] B_imm[15] B_imm[14] B_imm[13]
+ B_imm[12] B_imm[11] B_imm[10] B_imm[9] B_imm[8] B_imm[7] B_imm[6] B_imm[5]
+ B_imm[4] B_imm[3] B_imm[2] B_imm[1] B_imm[0] A_imm[31] A_imm[30] A_imm[29]
+ A_imm[28] A_imm[27] A_imm[26] A_imm[25] A_imm[24] A_imm[23] A_imm[22]
+ A_imm[21] A_imm[20] A_imm[19] A_imm[18] A_imm[17] A_imm[16] A_imm[15]
+ A_imm[14] A_imm[13] A_imm[12] A_imm[11] A_imm[10] A_imm[9] A_imm[8] A_imm[7]
+ A_imm[6] A_imm[5] A_imm[4] A_imm[3] A_imm[2] A_imm[1] A_imm[0] Res_imm[63]
+ Res_imm[62] Res_imm[61] Res_imm[60] Res_imm[59] Res_imm[58] Res_imm[57]
+ Res_imm[56] Res_imm[55] Res_imm[54] Res_imm[53] Res_imm[52] Res_imm[51]
+ Res_imm[50] Res_imm[49] Res_imm[48] Res_imm[47] Res_imm[46] Res_imm[45]
+ Res_imm[44] Res_imm[43] Res_imm[42] Res_imm[41] Res_imm[40] Res_imm[39]
+ Res_imm[38] Res_imm[37] Res_imm[36] Res_imm[35] Res_imm[34] Res_imm[33]
+ Res_imm[32] Res_imm[31] Res_imm[30] Res_imm[29] Res_imm[28] Res_imm[27]
+ Res_imm[26] Res_imm[25] Res_imm[24] Res_imm[23] Res_imm[22] Res_imm[21]
+ Res_imm[20] Res_imm[19] Res_imm[18] Res_imm[17] Res_imm[16] Res_imm[15]
+ Res_imm[14] Res_imm[13] Res_imm[12] Res_imm[11] Res_imm[10] Res_imm[9]
+ Res_imm[8] Res_imm[7] Res_imm[6] Res_imm[5] Res_imm[4] Res_imm[3] Res_imm[2]
+ Res_imm[1] Res_imm[0]
Xi_1340 INV_X1 $PINS ZN=n_1821 A=n_1812
Xi_1339 INV_X1 $PINS ZN=n_1820 A=n_1798
Xi_1338 INV_X1 $PINS ZN=n_1819 A=n_1795
Xi_1337 OAI21_X1 $PINS ZN=n_1818 A=n_1802 B1=n_1792 B2=n_1794
Xi_1336 OAI211_X1 $PINS ZN=n_1817 A=n_1786 B=n_1805 C1=n_1803 C2=n_1787
Xi_1335 INV_X1 $PINS ZN=n_1816 A=n_1817
Xi_1334 OAI221_X1 $PINS ZN=n_1815 A=n_1820 B1=n_1797 B2=n_1799 C1=n_1818
+ C2=n_1816
Xi_1333 AOI22_X1 $PINS ZN=n_1814 A1=n_1812 A2=n_1819 B1=n_1821 B2=n_1795
Xi_1332 XNOR2_X1 $PINS ZN=Res_imm[45] A=n_1815 B=n_1814
Xi_1331 NOR2_X1 $PINS ZN=n_1012 A1=hfn_ipo_n6 A2=n_1653
Xi_1330 NOR2_X1 $PINS ZN=n_1035 A1=hfn_ipo_n6 A2=n_1678
Xi_1329 FA_X1 $PINS CO=n_1813 S=n_1812 A=n_1012 B=n_1035 CI=n_1793
Xi_1328 INV_X1 $PINS ZN=n_1811 A=n_1799
Xi_1327 NOR2_X1 $PINS ZN=n_1810 A1=n_1806 A2=n_1801
Xi_1326 XOR2_X1 $PINS Z=Res_imm[44] A=n_1808 B=n_1809
Xi_1325 NOR2_X1 $PINS ZN=n_1809 A1=n_1798 A2=n_1797
Xi_1324 NAND2_X1 $PINS ZN=n_1808 A1=n_1807 A2=n_1799
Xi_1323 OAI21_X1 $PINS ZN=n_1807 A=n_1802 B1=n_1804 B2=n_1806
Xi_1322 INV_X1 $PINS ZN=n_1806 A=n_1805
Xi_1321 NAND2_X1 $PINS ZN=n_1805 A1=n_1796 A2=n_1784
Xi_1320 AOI21_X1 $PINS ZN=n_1804 A=n_1803 B1=n_1787 B2=n_1786
Xi_1319 NOR2_X1 $PINS ZN=n_1803 A1=n_1685 A2=n_1783
Xi_1318 NOR2_X1 $PINS ZN=n_1802 A1=n_1801 A2=n_1800
Xi_1317 NOR2_X1 $PINS ZN=n_1801 A1=n_1796 A2=n_1784
Xi_1316 NOR2_X1 $PINS ZN=n_1800 A1=n_1004 A2=n_999
Xi_1315 NAND2_X1 $PINS ZN=n_1799 A1=n_1004 A2=n_999
Xi_1314 AND2_X1 $PINS ZN=n_1798 A1=n_1792 A2=n_1794
Xi_1313 NOR2_X1 $PINS ZN=n_1797 A1=n_1792 A2=n_1794
Xi_1312 NOR2_X1 $PINS ZN=n_1014 A1=hfn_ipo_n6 A2=n_1651
Xi_1311 NOR2_X1 $PINS ZN=n_1037 A1=n_1678 A2=n_1652
Xi_1310 NOR2_X1 $PINS ZN=n_1060 A1=n_1677 A2=n_1653
Xi_1309 NOR2_X1 $PINS ZN=n_1083 A1=n_1676 A2=hfn_ipo_n6
Xi_1308 NOR2_X1 $PINS ZN=n_1015 A1=n_1650 A2=hfn_ipo_n6
Xi_1307 NOR2_X1 $PINS ZN=n_1038 A1=n_1678 A2=n_1651
Xi_1306 NOR2_X1 $PINS ZN=n_1061 A1=n_1677 A2=n_1652
Xi_1305 NOR2_X1 $PINS ZN=n_1084 A1=n_1676 A2=n_1653
Xi_1304 NOR2_X1 $PINS ZN=n_1107 A1=n_1675 A2=hfn_ipo_n6
Xi_1303 NOR2_X1 $PINS ZN=n_1013 A1=n_1652 A2=hfn_ipo_n6
Xi_1302 NOR2_X1 $PINS ZN=n_1036 A1=n_1653 A2=n_1678
Xi_1301 NOR2_X1 $PINS ZN=n_1059 A1=n_1677 A2=hfn_ipo_n6
Xi_1300 FA_X1 $PINS CO=n_999 S=n_1796 A=n_1781 B=n_1782 CI=n_996
Xi_1299 FA_X1 $PINS CO=n_1795 S=n_1794 A=n_1001 B=n_1006 CI=n_1003
Xi_1298 FA_X1 $PINS CO=n_1793 S=n_1006 A=n_1013 B=n_1036 CI=n_1059
Xi_1297 FA_X1 $PINS CO=n_1792 S=n_1004 A=n_1000 B=n_1002 CI=n_997
Xi_1296 FA_X1 $PINS CO=n_997 S=n_996 A=n_1780 B=n_994 CI=n_992
Xi_1295 FA_X1 $PINS CO=n_1003 S=n_1002 A=n_1083 B=n_993 CI=n_995
Xi_1294 FA_X1 $PINS CO=n_995 S=n_994 A=n_1084 B=n_1107 CI=n_1779
Xi_1293 FA_X1 $PINS CO=n_993 S=n_992 A=n_1015 B=n_1038 CI=n_1061
Xi_1292 FA_X1 $PINS CO=n_1001 S=n_1000 A=n_1014 B=n_1037 CI=n_1060
Xi_1291 NOR2_X1 $PINS ZN=n_1791 A1=n_1687 A2=n_1679
Xi_1290 NOR2_X1 $PINS ZN=n_1790 A1=n_1774 A2=n_1771
Xi_1289 NOR3_X1 $PINS ZN=n_1789 A1=n_1774 A2=n_1791 A3=n_1769
Xi_1288 OAI211_X2 $PINS ZN=n_1788 A=n_1719 B=n_1768 C1=n_1766 C2=n_1720
Xi_1287 AOI211_X2 $PINS ZN=n_1787 A=n_1772 B=n_1790 C1=n_1789 C2=n_1788
Xi_1286 NAND2_X1 $PINS ZN=n_1786 A1=n_1783 A2=n_1685
Xi_1285 OAI21_X1 $PINS ZN=n_1785 A=n_1786 B1=n_1783 B2=n_1685
Xi_1284 XOR2_X1 $PINS Z=Res_imm[41] A=n_1787 B=n_1785
Xi_1283 NOR2_X1 $PINS ZN=n_1085 A1=n_1676 A2=n_1652
Xi_1282 NOR2_X1 $PINS ZN=n_1108 A1=n_1675 A2=n_1653
Xi_1281 NOR2_X1 $PINS ZN=n_1131 A1=n_1674 A2=hfn_ipo_n6
Xi_1280 NOR2_X1 $PINS ZN=n_1016 A1=hfn_ipo_n6 A2=n_1649
Xi_1279 NOR2_X1 $PINS ZN=n_1039 A1=n_1678 A2=n_1650
Xi_1278 NOR2_X1 $PINS ZN=n_1062 A1=n_1677 A2=n_1651
Xi_1277 FA_X1 $PINS CO=n_1784 S=n_1783 A=n_1682 B=n_1684 CI=n_988
Xi_1276 FA_X1 $PINS CO=n_1782 S=n_988 A=n_984 B=n_982 CI=n_986
Xi_1275 FA_X1 $PINS CO=n_1781 S=n_986 A=n_1680 B=n_1681 CI=n_1683
Xi_1274 FA_X1 $PINS CO=n_1780 S=n_982 A=n_1016 B=n_1039 CI=n_1062
Xi_1273 FA_X1 $PINS CO=n_1779 S=n_984 A=n_1085 B=n_1108 CI=n_1131
Xi_1272 INV_X1 $PINS ZN=n_1778 A=n_1701
Xi_1271 INV_X1 $PINS ZN=n_1777 A=n_1705
Xi_1270 INV_X1 $PINS ZN=n_1776 A=n_769
Xi_1269 INV_X1 $PINS ZN=n_1775 A=n_761
Xi_1268 NOR2_X1 $PINS ZN=n_1774 A1=n_969 A2=n_980
Xi_1267 AND2_X1 $PINS ZN=n_1772 A1=n_969 A2=n_980
Xi_1266 NAND2_X1 $PINS ZN=n_1771 A1=n_1679 A2=n_1687
Xi_1265 INV_X1 $PINS ZN=n_1770 A=n_1771
Xi_1264 NOR2_X1 $PINS ZN=n_1769 A1=n_1686 A2=n_1693
Xi_1263 NAND2_X1 $PINS ZN=n_1768 A1=n_1686 A2=n_1693
Xi_1262 NOR2_X1 $PINS ZN=n_1766 A1=n_1692 A2=n_1694
Xi_1261 NAND2_X1 $PINS ZN=n_1764 A1=n_920 A2=n_901
Xi_1260 INV_X1 $PINS ZN=n_1762 A=n_1764
Xi_1259 NOR2_X1 $PINS ZN=n_1761 A1=n_920 A2=n_901
Xi_1258 NAND2_X1 $PINS ZN=n_1760 A1=n_1695 A2=n_1697
Xi_1257 NOR2_X1 $PINS ZN=n_1759 A1=n_1695 A2=n_1697
Xi_1256 NOR2_X1 $PINS ZN=n_1758 A1=n_1696 A2=n_1699
Xi_1255 NAND2_X1 $PINS ZN=n_1755 A1=n_1698 A2=n_1703
Xi_1254 NAND2_X1 $PINS ZN=n_1754 A1=n_1696 A2=n_1699
Xi_1253 NOR2_X1 $PINS ZN=n_1753 A1=n_1698 A2=n_1703
Xi_1252 NAND2_X1 $PINS ZN=n_1752 A1=n_1704 A2=n_1707
Xi_1251 AND2_X1 $PINS ZN=n_1751 A1=n_1712 A2=n_168
Xi_1250 AOI21_X1 $PINS ZN=n_1746 A=n_768 B1=n_760 B2=n_758
Xi_1249 AOI221_X1 $PINS ZN=n_1745 A=n_1746 B1=n_1708 B2=n_1713 C1=n_1776
+ C2=n_1751
Xi_1248 AND2_X1 $PINS ZN=n_1744 A1=n_1706 A2=n_1711
Xi_1247 NOR2_X1 $PINS ZN=n_1743 A1=n_768 A2=n_764
Xi_1246 INV_X1 $PINS ZN=n_1742 A=n_1743
Xi_1245 OAI21_X1 $PINS ZN=n_1741 A=n_762 B1=n_1586 B2=n_1585
Xi_1244 AOI21_X1 $PINS ZN=n_1740 A=n_1741 B1=n_775 B2=n_900
Xi_1243 INV_X1 $PINS ZN=n_1739 A=n_1740
Xi_1242 NAND2_X1 $PINS ZN=n_1738 A1=n_1536 A2=n_771
Xi_1241 NOR2_X1 $PINS ZN=n_1737 A1=n_1701 A2=n_1705
Xi_1240 NOR2_X1 $PINS ZN=n_1736 A1=n_1709 A2=n_1710
Xi_1239 AOI21_X2 $PINS ZN=n_1735 A=n_1738 B1=n_979 B2=n_987
Xi_1238 OAI21_X1 $PINS ZN=n_1734 A=n_1743 B1=n_1739 B2=n_1735
Xi_1237 AOI21_X1 $PINS ZN=n_1733 A=n_1736 B1=n_1745 B2=n_1734
Xi_1236 NOR3_X1 $PINS ZN=n_1732 A1=n_1775 A2=n_1744 A3=n_1733
Xi_1235 OR3_X2 $PINS ZN=n_1731 A1=n_770 A2=n_1737 A3=n_1732
Xi_1234 OAI221_X2 $PINS ZN=n_1730 A=n_1731 B1=n_1778 B2=n_1777 C1=n_1752
+ C2=n_1737
Xi_1233 INV_X1 $PINS ZN=n_1729 A=n_1730
Xi_1232 OR3_X1 $PINS ZN=n_1728 A1=n_1761 A2=n_1758 A3=n_1759
Xi_1231 NOR2_X1 $PINS ZN=n_1727 A1=n_1753 A2=n_1728
Xi_1230 AND2_X1 $PINS ZN=n_1726 A1=n_1755 A2=n_1754
Xi_1229 OAI221_X1 $PINS ZN=n_1725 A=n_1764 B1=n_1761 B2=n_1760 C1=n_1728
+ C2=n_1726
Xi_1228 AOI21_X4 $PINS ZN=n_1720 A=n_1725 B1=n_1730 B2=n_1727
Xi_1227 NAND2_X1 $PINS ZN=n_1719 A1=n_1692 A2=n_1694
Xi_1226 AOI21_X1 $PINS ZN=n_1718 A=n_1766 B1=n_1720 B2=n_1719
Xi_1225 INV_X1 $PINS ZN=n_1717 A=n_1718
Xi_1224 AOI21_X1 $PINS ZN=n_1716 A=n_1769 B1=n_1768 B2=n_1717
Xi_1223 OR2_X1 $PINS ZN=n_1715 A1=n_1774 A2=n_1772
Xi_1222 OAI22_X1 $PINS ZN=n_1714 A1=n_1679 A2=n_1687 B1=n_1770 B2=n_1716
Xi_1221 XOR2_X2 $PINS Z=Res_imm[40] A=n_1715 B=n_1714
Xi_1220 NOR2_X1 $PINS ZN=n_1156 A1=n_1673 A2=n_1653
Xi_1219 NOR2_X1 $PINS ZN=n_1179 A1=n_1672 A2=hfn_ipo_n6
Xi_1218 NOR2_X1 $PINS ZN=n_1157 A1=n_1673 A2=n_1652
Xi_1217 NOR2_X1 $PINS ZN=n_1180 A1=n_1653 A2=n_1672
Xi_1216 NOR2_X1 $PINS ZN=n_1203 A1=hfn_ipo_n6 A2=n_1670
Xi_1215 NOR2_X1 $PINS ZN=n_1087 A1=n_1676 A2=n_1650
Xi_1214 NOR2_X1 $PINS ZN=n_1110 A1=n_1675 A2=n_1651
Xi_1213 NOR2_X1 $PINS ZN=n_1133 A1=n_1652 A2=n_1674
Xi_1212 NOR2_X1 $PINS ZN=n_1018 A1=hfn_ipo_n6 A2=n_1647
Xi_1211 NOR2_X1 $PINS ZN=n_1041 A1=n_1678 A2=n_1648
Xi_1210 NOR2_X1 $PINS ZN=n_1064 A1=n_1677 A2=n_1649
Xi_1209 NOR2_X1 $PINS ZN=n_1088 A1=n_1676 A2=n_1649
Xi_1208 NOR2_X1 $PINS ZN=n_1111 A1=n_1650 A2=n_1675
Xi_1207 NOR2_X1 $PINS ZN=n_1134 A1=n_1651 A2=n_1674
Xi_1206 NOR2_X1 $PINS ZN=n_1019 A1=hfn_ipo_n6 A2=n_1646
Xi_1205 NOR2_X1 $PINS ZN=n_1042 A1=n_1647 A2=n_1678
Xi_1204 NOR2_X1 $PINS ZN=n_1065 A1=n_1648 A2=n_1677
Xi_1203 NOR2_X1 $PINS ZN=n_1158 A1=n_1673 A2=n_1651
Xi_1202 NOR2_X1 $PINS ZN=n_1181 A1=n_1672 A2=n_1652
Xi_1201 NOR2_X1 $PINS ZN=n_1204 A1=n_1653 A2=n_1670
Xi_1200 NOR2_X1 $PINS ZN=n_1089 A1=n_1676 A2=n_1648
Xi_1199 NOR2_X1 $PINS ZN=n_1112 A1=n_1675 A2=n_1649
Xi_1198 NOR2_X1 $PINS ZN=n_1135 A1=n_1650 A2=n_1674
Xi_1197 NOR2_X1 $PINS ZN=n_1020 A1=hfn_ipo_n6 A2=n_1645
Xi_1196 NOR2_X1 $PINS ZN=n_1043 A1=n_1678 A2=n_1646
Xi_1195 NOR2_X1 $PINS ZN=n_1066 A1=n_1647 A2=n_1677
Xi_1194 NOR2_X1 $PINS ZN=n_1227 A1=hfn_ipo_n6 A2=n_1669
Xi_1193 NOR2_X1 $PINS ZN=n_1159 A1=n_1673 A2=n_1650
Xi_1192 NOR2_X1 $PINS ZN=n_1182 A1=n_1672 A2=n_1651
Xi_1191 NOR2_X1 $PINS ZN=n_1205 A1=n_1652 A2=n_1670
Xi_1190 NOR2_X1 $PINS ZN=n_1090 A1=n_1676 A2=n_1647
Xi_1189 NOR2_X1 $PINS ZN=n_1113 A1=n_1675 A2=n_1648
Xi_1188 NOR2_X1 $PINS ZN=n_1136 A1=n_1674 A2=n_1649
Xi_1187 NOR2_X1 $PINS ZN=n_1021 A1=hfn_ipo_n6 A2=n_1644
Xi_1186 NOR2_X1 $PINS ZN=n_1044 A1=n_1678 A2=n_1645
Xi_1185 NOR2_X1 $PINS ZN=n_1067 A1=n_1677 A2=n_1646
Xi_1184 NOR2_X1 $PINS ZN=n_1160 A1=n_1673 A2=n_1649
Xi_1183 NOR2_X1 $PINS ZN=n_1183 A1=n_1672 A2=n_1650
Xi_1182 NOR2_X1 $PINS ZN=n_1206 A1=n_1670 A2=n_1651
Xi_1181 NOR2_X1 $PINS ZN=n_1091 A1=n_1676 A2=n_1646
Xi_1180 NOR2_X1 $PINS ZN=n_1114 A1=n_1675 A2=n_1647
Xi_1179 NOR2_X1 $PINS ZN=n_1137 A1=n_1674 A2=n_1648
Xi_1178 NOR2_X1 $PINS ZN=n_1022 A1=hfn_ipo_n6 A2=n_1643
Xi_1177 NOR2_X1 $PINS ZN=n_1045 A1=n_1678 A2=n_1644
Xi_1176 NOR2_X1 $PINS ZN=n_1068 A1=n_1677 A2=n_1645
Xi_1175 NOR2_X1 $PINS ZN=n_1228 A1=n_1653 A2=n_1669
Xi_1174 NOR2_X1 $PINS ZN=n_1251 A1=hfn_ipo_n6 A2=n_1668
Xi_1173 NOR2_X1 $PINS ZN=n_1229 A1=n_1652 A2=n_1669
Xi_1172 NOR2_X1 $PINS ZN=n_1252 A1=n_1653 A2=n_1668
Xi_1171 NOR2_X1 $PINS ZN=n_1275 A1=hfn_ipo_n6 A2=n_1667
Xi_1170 NOR2_X1 $PINS ZN=n_1086 A1=n_1676 A2=n_1651
Xi_1169 NOR2_X1 $PINS ZN=n_1109 A1=n_1652 A2=n_1675
Xi_1168 NOR2_X1 $PINS ZN=n_1132 A1=n_1653 A2=n_1674
Xi_1167 NOR2_X1 $PINS ZN=n_1017 A1=hfn_ipo_n6 A2=n_1648
Xi_1166 NOR2_X1 $PINS ZN=n_1040 A1=n_1678 A2=n_1649
Xi_1165 NOR2_X1 $PINS ZN=n_1063 A1=n_1650 A2=n_1677
Xi_1164 NOR2_X1 $PINS ZN=n_1155 A1=n_1673 A2=hfn_ipo_n6
Xi_1163 NOR2_X1 $PINS ZN=n_1230 A1=n_1651 A2=n_1669
Xi_1162 NOR2_X1 $PINS ZN=n_1253 A1=n_1652 A2=n_1668
Xi_1161 NOR2_X1 $PINS ZN=n_1276 A1=n_1653 A2=n_1667
Xi_1160 NOR2_X1 $PINS ZN=n_1161 A1=n_1673 A2=n_1648
Xi_1159 NOR2_X1 $PINS ZN=n_1184 A1=n_1672 A2=n_1649
Xi_1158 NOR2_X1 $PINS ZN=n_1207 A1=n_1670 A2=n_1650
Xi_1157 NOR2_X1 $PINS ZN=n_1092 A1=n_1676 A2=n_1645
Xi_1156 NOR2_X1 $PINS ZN=n_1115 A1=n_1675 A2=n_1646
Xi_1155 NOR2_X1 $PINS ZN=n_1138 A1=n_1674 A2=n_1647
Xi_1154 NOR2_X1 $PINS ZN=n_1023 A1=hfn_ipo_n6 A2=n_1642
Xi_1153 NOR2_X1 $PINS ZN=n_1046 A1=n_1678 A2=n_1643
Xi_1152 NOR2_X1 $PINS ZN=n_1069 A1=n_1677 A2=n_1644
Xi_1151 NOR2_X1 $PINS ZN=n_1299 A1=hfn_ipo_n6 A2=n_1666
Xi_1150 NOR2_X1 $PINS ZN=n_1231 A1=n_1650 A2=n_1669
Xi_1149 NOR2_X1 $PINS ZN=n_1254 A1=n_1651 A2=n_1668
Xi_1148 NOR2_X1 $PINS ZN=n_1277 A1=n_1652 A2=n_1667
Xi_1147 NOR2_X1 $PINS ZN=n_1162 A1=n_1673 A2=n_1647
Xi_1146 NOR2_X1 $PINS ZN=n_1185 A1=n_1672 A2=n_1648
Xi_1145 NOR2_X1 $PINS ZN=n_1208 A1=n_1670 A2=n_1649
Xi_1144 NOR2_X1 $PINS ZN=n_1093 A1=n_1676 A2=n_1644
Xi_1143 NOR2_X1 $PINS ZN=n_1116 A1=n_1675 A2=n_1645
Xi_1142 NOR2_X1 $PINS ZN=n_1139 A1=n_1674 A2=n_1646
Xi_1141 NOR2_X1 $PINS ZN=n_1024 A1=hfn_ipo_n6 A2=n_1641
Xi_1140 NOR2_X1 $PINS ZN=n_1047 A1=n_1678 A2=n_1642
Xi_1139 NOR2_X1 $PINS ZN=n_1070 A1=n_1677 A2=n_1643
Xi_1138 NOR2_X1 $PINS ZN=n_1232 A1=n_1649 A2=n_1669
Xi_1137 NOR2_X1 $PINS ZN=n_1255 A1=n_1650 A2=n_1668
Xi_1136 NOR2_X1 $PINS ZN=n_1278 A1=n_1651 A2=n_1667
Xi_1135 NOR2_X1 $PINS ZN=n_1163 A1=n_1673 A2=n_1646
Xi_1134 NOR2_X1 $PINS ZN=n_1186 A1=n_1672 A2=n_1647
Xi_1133 NOR2_X1 $PINS ZN=n_1209 A1=n_1670 A2=n_1648
Xi_1132 NOR2_X1 $PINS ZN=n_1094 A1=n_1676 A2=n_1643
Xi_1131 NOR2_X1 $PINS ZN=n_1117 A1=n_1675 A2=n_1644
Xi_1130 NOR2_X1 $PINS ZN=n_1140 A1=n_1674 A2=n_1645
Xi_1129 NOR2_X1 $PINS ZN=n_1300 A1=n_1653 A2=n_1666
Xi_1128 NOR2_X1 $PINS ZN=n_1323 A1=hfn_ipo_n6 A2=n_1665
Xi_1127 NOR2_X1 $PINS ZN=n_1301 A1=n_1652 A2=n_1666
Xi_1126 NOR2_X1 $PINS ZN=n_1324 A1=n_1653 A2=n_1665
Xi_1125 NOR2_X1 $PINS ZN=n_1347 A1=n_1654 A2=n_1664
Xi_1124 NOR2_X1 $PINS ZN=n_1025 A1=hfn_ipo_n6 A2=n_1640
Xi_1123 NOR2_X1 $PINS ZN=n_1048 A1=n_1678 A2=n_1641
Xi_1122 NOR2_X1 $PINS ZN=n_1071 A1=n_1677 A2=n_1642
Xi_1121 FA_X1 $PINS CO=n_1713 S=n_1712 A=n_169 B=n_167 CI=n_461
Xi_1120 FA_X1 $PINS CO=n_1711 S=n_1710 A=n_515 B=n_509 CI=n_517
Xi_1119 FA_X1 $PINS CO=n_1709 S=n_1708 A=n_505 B=n_504 CI=n_507
Xi_1118 FA_X1 $PINS CO=n_1707 S=n_1706 A=n_766 B=n_519 CI=n_533
Xi_1117 FA_X1 $PINS CO=n_1705 S=n_1704 A=n_796 B=n_535 CI=n_798
Xi_1116 FA_X1 $PINS CO=n_1703 S=n_1701 A=n_824 B=n_799 CI=n_826
Xi_1115 FA_X1 $PINS CO=n_797 S=n_796 A=n_548 B=n_629 CI=n_664
Xi_1114 FA_X1 $PINS CO=n_799 S=n_798 A=n_765 B=n_794 CI=n_767
Xi_1113 FA_X1 $PINS CO=n_767 S=n_766 A=n_513 B=n_529 CI=n_525
Xi_1112 FA_X1 $PINS CO=n_765 S=n_1700 A=n_511 B=n_523 CI=n_521
Xi_1111 FA_X1 $PINS CO=n_795 S=n_794 A=n_545 B=n_527 CI=n_531
Xi_1110 FA_X1 $PINS CO=n_1699 S=n_1698 A=n_850 B=n_827 CI=n_852
Xi_1109 FA_X1 $PINS CO=n_827 S=n_826 A=n_820 B=n_822 CI=n_797
Xi_1108 FA_X1 $PINS CO=n_1697 S=n_1696 A=n_853 B=n_874 CI=n_876
Xi_1107 FA_X1 $PINS CO=n_853 S=n_852 A=n_823 B=n_848 CI=n_825
Xi_1106 FA_X1 $PINS CO=n_825 S=n_824 A=n_818 B=n_816 CI=n_795
Xi_1105 FA_X1 $PINS CO=n_823 S=n_822 A=n_547 B=n_666 CI=n_631
Xi_1104 FA_X1 $PINS CO=n_901 S=n_1695 A=n_896 B=n_877 CI=n_898
Xi_1103 FA_X1 $PINS CO=n_877 S=n_876 A=n_849 B=n_872 CI=n_851
Xi_1102 FA_X1 $PINS CO=n_851 S=n_850 A=n_821 B=n_844 CI=n_846
Xi_1101 FA_X1 $PINS CO=n_821 S=n_820 A=n_814 B=n_812 CI=n_549
Xi_1100 FA_X1 $PINS CO=n_849 S=n_848 A=n_819 B=n_817 CI=n_842
Xi_1099 FA_X1 $PINS CO=n_817 S=n_816 A=n_541 B=n_810 CI=n_808
Xi_1098 FA_X1 $PINS CO=n_819 S=n_818 A=n_806 B=n_804 CI=n_802
Xi_1097 FA_X1 $PINS CO=n_1694 S=n_920 A=n_916 B=n_899 CI=n_918
Xi_1096 FA_X1 $PINS CO=n_899 S=n_898 A=n_892 B=n_894 CI=n_875
Xi_1095 FA_X1 $PINS CO=n_875 S=n_874 A=n_847 B=n_870 CI=n_868
Xi_1094 FA_X1 $PINS CO=n_847 S=n_846 A=n_830 B=n_815 CI=n_840
Xi_1093 FA_X1 $PINS CO=n_815 S=n_814 A=n_539 B=n_537 CI=n_543
Xi_1092 FA_X1 $PINS CO=n_1693 S=n_1692 A=n_934 B=n_919 CI=n_936
Xi_1091 FA_X1 $PINS CO=n_919 S=n_918 A=n_914 B=n_912 CI=n_897
Xi_1090 FA_X1 $PINS CO=n_897 S=n_896 A=n_890 B=n_873 CI=n_871
Xi_1089 FA_X1 $PINS CO=n_871 S=n_870 A=n_858 B=n_856 CI=n_866
Xi_1088 FA_X1 $PINS CO=n_873 S=n_872 A=n_864 B=n_845 CI=n_843
Xi_1087 FA_X1 $PINS CO=n_843 S=n_842 A=n_803 B=n_813 CI=n_838
Xi_1086 FA_X1 $PINS CO=n_813 S=n_812 A=n_781 B=n_779 CI=n_777
Xi_1085 FA_X1 $PINS CO=n_777 S=n_1691 A=n_667 B=n_668 CI=n_669
Xi_1084 FA_X1 $PINS CO=n_779 S=n_1690 A=n_702 B=n_704 CI=n_729
Xi_1083 FA_X1 $PINS CO=n_781 S=n_1688 A=n_731 B=n_734 CI=n_736
Xi_1082 FA_X1 $PINS CO=n_803 S=n_802 A=n_1025 B=n_1048 CI=n_1071
Xi_1081 FA_X1 $PINS CO=n_845 S=n_844 A=n_836 B=n_834 CI=n_832
Xi_1080 FA_X1 $PINS CO=n_1687 S=n_1686 A=n_935 B=n_937 CI=n_952
Xi_1079 FA_X1 $PINS CO=n_937 S=n_936 A=n_915 B=n_932 CI=n_917
Xi_1078 FA_X1 $PINS CO=n_917 S=n_916 A=n_893 B=n_891 CI=n_895
Xi_1077 FA_X1 $PINS CO=n_895 S=n_894 A=n_867 B=n_888 CI=n_869
Xi_1076 FA_X1 $PINS CO=n_869 S=n_868 A=n_839 B=n_862 CI=n_860
Xi_1075 FA_X1 $PINS CO=n_839 S=n_838 A=n_1300 B=n_1323 CI=n_811
Xi_1074 FA_X1 $PINS CO=n_811 S=n_810 A=n_1301 B=n_1324 CI=n_1347
Xi_1073 FA_X1 $PINS CO=n_867 S=n_866 A=n_833 B=n_831 CI=n_841
Xi_1072 FA_X1 $PINS CO=n_841 S=n_840 A=n_809 B=n_807 CI=n_805
Xi_1071 FA_X1 $PINS CO=n_805 S=n_804 A=n_1094 B=n_1117 CI=n_1140
Xi_1070 FA_X1 $PINS CO=n_807 S=n_806 A=n_1163 B=n_1186 CI=n_1209
Xi_1069 FA_X1 $PINS CO=n_809 S=n_808 A=n_1232 B=n_1255 CI=n_1278
Xi_1068 FA_X1 $PINS CO=n_831 S=n_830 A=n_1024 B=n_1047 CI=n_1070
Xi_1065 FA_X1 $PINS CO=n_833 S=n_832 A=n_1093 B=n_1116 CI=n_1139
Xi_1063 FA_X1 $PINS CO=n_891 S=n_890 A=n_857 B=n_865 CI=n_886
Xi_1062 FA_X1 $PINS CO=n_865 S=n_864 A=n_1299 B=n_837 CI=n_835
Xi_1061 FA_X1 $PINS CO=n_835 S=n_834 A=n_1162 B=n_1185 CI=n_1208
Xi_1060 FA_X1 $PINS CO=n_837 S=n_836 A=n_1231 B=n_1254 CI=n_1277
Xi_1059 FA_X1 $PINS CO=n_857 S=n_856 A=n_1023 B=n_1046 CI=n_1069
Xi_1058 FA_X1 $PINS CO=n_893 S=n_892 A=n_884 B=n_882 CI=n_880
Xi_1057 FA_X1 $PINS CO=n_915 S=n_914 A=n_904 B=n_902 CI=n_910
Xi_1056 FA_X1 $PINS CO=n_935 S=n_934 A=n_928 B=n_913 CI=n_930
Xi_1055 FA_X1 $PINS CO=n_913 S=n_912 A=n_889 B=n_908 CI=n_906
Xi_1054 FA_X1 $PINS CO=n_889 S=n_888 A=n_863 B=n_861 CI=n_859
Xi_1053 FA_X1 $PINS CO=n_859 S=n_858 A=n_1092 B=n_1115 CI=n_1138
Xi_1052 FA_X1 $PINS CO=n_861 S=n_860 A=n_1161 B=n_1184 CI=n_1207
Xi_1051 FA_X1 $PINS CO=n_863 S=n_862 A=n_1230 B=n_1253 CI=n_1276
Xi_1050 FA_X1 $PINS CO=n_1685 S=n_980 A=n_976 B=n_967 CI=n_978
Xi_1049 FA_X1 $PINS CO=n_1684 S=n_978 A=n_963 B=n_974 CI=n_965
Xi_1048 FA_X1 $PINS CO=n_1683 S=n_974 A=n_1155 B=n_959 CI=n_957
Xi_1047 FA_X1 $PINS CO=n_1682 S=n_976 A=n_961 B=n_972 CI=n_970
Xi_1045 FA_X1 $PINS CO=n_1681 S=n_970 A=n_1017 B=n_1040 CI=n_1063
Xi_1044 FA_X1 $PINS CO=n_1680 S=n_972 A=n_1086 B=n_1109 CI=n_1132
Xi_1042 FA_X1 $PINS CO=n_969 S=n_1679 A=n_964 B=n_966 CI=n_953
Xi_1041 FA_X1 $PINS CO=n_953 S=n_952 A=n_933 B=n_948 CI=n_950
Xi_1040 FA_X1 $PINS CO=n_933 S=n_932 A=n_926 B=n_924 CI=n_922
Xi_1039 FA_X1 $PINS CO=n_967 S=n_966 A=n_962 B=n_949 CI=n_951
Xi_1038 FA_X1 $PINS CO=n_951 S=n_950 A=n_940 B=n_931 CI=n_946
Xi_1037 FA_X1 $PINS CO=n_931 S=n_930 A=n_903 B=n_911 CI=n_909
Xi_1036 FA_X1 $PINS CO=n_909 S=n_908 A=n_1228 B=n_1251 CI=n_887
Xi_1035 FA_X1 $PINS CO=n_887 S=n_886 A=n_1229 B=n_1252 CI=n_1275
Xi_1034 FA_X1 $PINS CO=n_911 S=n_910 A=n_885 B=n_883 CI=n_881
Xi_1033 FA_X1 $PINS CO=n_881 S=n_880 A=n_1022 B=n_1045 CI=n_1068
Xi_1032 FA_X1 $PINS CO=n_883 S=n_882 A=n_1091 B=n_1114 CI=n_1137
Xi_1031 FA_X1 $PINS CO=n_885 S=n_884 A=n_1160 B=n_1183 CI=n_1206
Xi_1030 FA_X1 $PINS CO=n_903 S=n_902 A=n_1021 B=n_1044 CI=n_1067
Xi_1029 FA_X1 $PINS CO=n_949 S=n_948 A=n_929 B=n_944 CI=n_942
Xi_1028 FA_X1 $PINS CO=n_929 S=n_928 A=n_1227 B=n_907 CI=n_905
Xi_1027 FA_X1 $PINS CO=n_905 S=n_904 A=n_1090 B=n_1113 CI=n_1136
Xi_1026 FA_X1 $PINS CO=n_907 S=n_906 A=n_1159 B=n_1182 CI=n_1205
Xi_1025 FA_X1 $PINS CO=n_963 S=n_962 A=n_943 B=n_941 CI=n_947
Xi_1024 FA_X1 $PINS CO=n_947 S=n_946 A=n_927 B=n_925 CI=n_923
Xi_1022 FA_X1 $PINS CO=n_923 S=n_922 A=n_1020 B=n_1043 CI=n_1066
Xi_1019 FA_X1 $PINS CO=n_925 S=n_924 A=n_1089 B=n_1112 CI=n_1135
Xi_1018 FA_X1 $PINS CO=n_927 S=n_926 A=n_1158 B=n_1181 CI=n_1204
Xi_1017 FA_X1 $PINS CO=n_941 S=n_940 A=n_1019 B=n_1042 CI=n_1065
Xi_1016 FA_X1 $PINS CO=n_943 S=n_942 A=n_1088 B=n_1111 CI=n_1134
Xi_1015 FA_X1 $PINS CO=n_965 S=n_964 A=n_960 B=n_958 CI=n_956
Xi_1014 FA_X1 $PINS CO=n_957 S=n_956 A=n_1018 B=n_1041 CI=n_1064
Xi_1013 FA_X1 $PINS CO=n_959 S=n_958 A=n_1087 B=n_1110 CI=n_1133
Xi_1012 FA_X1 $PINS CO=n_961 S=n_960 A=n_1156 B=n_1179 CI=n_945
Xi_1011 FA_X1 $PINS CO=n_945 S=n_944 A=n_1157 B=n_1180 CI=n_1203
Xi_1010 INV_X2 $PINS ZN=n_1678 A=B_imm[22]
Xi_1009 INV_X2 $PINS ZN=n_1677 A=B_imm[21]
Xi_1008 INV_X2 $PINS ZN=n_1676 A=B_imm[20]
Xi_1007 INV_X4 $PINS ZN=n_1675 A=B_imm[19]
Xi_1006 INV_X4 $PINS ZN=n_1674 A=B_imm[18]
Xi_1005 INV_X4 $PINS ZN=n_1673 A=B_imm[17]
Xi_1004 INV_X4 $PINS ZN=n_1672 A=B_imm[16]
Xi_1003 INV_X4 $PINS ZN=n_1670 A=B_imm[15]
Xi_1002 INV_X4 $PINS ZN=n_1669 A=B_imm[14]
Xi_1001 INV_X4 $PINS ZN=n_1668 A=B_imm[13]
Xi_999 INV_X4 $PINS ZN=n_1667 A=B_imm[12]
Xi_996 INV_X4 $PINS ZN=n_1666 A=B_imm[11]
Xi_995 INV_X4 $PINS ZN=n_1665 A=B_imm[10]
Xi_994 INV_X4 $PINS ZN=n_1664 A=B_imm[9]
Xi_993 INV_X4 $PINS ZN=n_1663 A=B_imm[8]
Xi_992 INV_X4 $PINS ZN=n_1662 A=B_imm[7]
Xi_991 INV_X4 $PINS ZN=n_1661 A=B_imm[6]
Xi_990 INV_X2 $PINS ZN=n_1660 A=B_imm[5]
Xi_989 INV_X2 $PINS ZN=n_1659 A=B_imm[4]
Xi_988 INV_X2 $PINS ZN=n_1658 A=B_imm[3]
Xi_987 INV_X2 $PINS ZN=n_1657 A=B_imm[2]
Xi_986 INV_X2 $PINS ZN=n_1656 A=B_imm[1]
Xi_985 INV_X2 $PINS ZN=n_1655 A=B_imm[0]
Xi_984 INV_X1 $PINS ZN=n_1654 A=A_imm[23]
Xi_983 INV_X2 $PINS ZN=n_1653 A=A_imm[22]
Xi_982 INV_X2 $PINS ZN=n_1652 A=A_imm[21]
Xi_981 INV_X4 $PINS ZN=n_1651 A=A_imm[20]
Xi_980 INV_X4 $PINS ZN=n_1650 A=A_imm[19]
Xi_979 INV_X4 $PINS ZN=n_1649 A=A_imm[18]
Xi_978 INV_X2 $PINS ZN=n_1648 A=A_imm[17]
Xi_973 INV_X4 $PINS ZN=n_1647 A=A_imm[16]
Xi_972 INV_X2 $PINS ZN=n_1646 A=A_imm[15]
Xi_971 INV_X2 $PINS ZN=n_1645 A=A_imm[14]
Xi_970 INV_X4 $PINS ZN=n_1644 A=A_imm[13]
Xi_969 INV_X2 $PINS ZN=n_1643 A=A_imm[12]
Xi_968 INV_X4 $PINS ZN=n_1642 A=A_imm[11]
Xi_967 INV_X4 $PINS ZN=n_1641 A=A_imm[10]
Xi_966 INV_X4 $PINS ZN=n_1640 A=A_imm[9]
Xi_965 INV_X4 $PINS ZN=n_1639 A=A_imm[8]
Xi_964 INV_X8 $PINS ZN=n_1634 A=A_imm[7]
Xi_963 INV_X8 $PINS ZN=n_1633 A=A_imm[6]
Xi_962 INV_X4 $PINS ZN=n_1632 A=A_imm[5]
Xi_961 INV_X8 $PINS ZN=n_1631 A=A_imm[4]
Xi_960 INV_X8 $PINS ZN=n_1630 A=A_imm[3]
Xi_959 INV_X4 $PINS ZN=n_1629 A=A_imm[2]
Xi_958 INV_X4 $PINS ZN=n_1628 A=A_imm[1]
Xi_957 INV_X4 $PINS ZN=n_1625 A=A_imm[0]
Xi_956 INV_X1 $PINS ZN=n_1623 A=n_763
Xi_955 INV_X1 $PINS ZN=n_1622 A=n_418
Xi_950 INV_X1 $PINS ZN=n_1621 A=n_340
Xi_949 INV_X1 $PINS ZN=n_1619 A=n_379
Xi_948 INV_X1 $PINS ZN=n_1608 A=n_305
Xi_947 NOR2_X1 $PINS ZN=n_1586 A1=n_775 A2=n_900
Xi_946 NAND2_X1 $PINS ZN=n_1585 A1=n_773 A2=n_938
Xi_945 INV_X1 $PINS ZN=n_1584 A=n_1585
Xi_944 NOR2_X1 $PINS ZN=n_1583 A1=n_460 A2=n_419
Xi_943 NAND2_X1 $PINS ZN=n_1569 A1=n_460 A2=n_419
Xi_942 NAND2_X1 $PINS ZN=n_1536 A1=n_1622 A2=n_1619
Xi_941 NOR2_X1 $PINS ZN=n_1513 A1=n_1622 A2=n_1619
Xi_940 AOI22_X1 $PINS ZN=n_1490 A1=n_52 A2=n_54 B1=n_38 B2=n_40
Xi_939 AOI22_X1 $PINS ZN=n_1348 A1=n_16 A2=n_18 B1=n_26 B2=n_28
Xi_938 AOI21_X1 $PINS ZN=n_1325 A=n_1623 B1=n_954 B2=n_955
Xi_937 NOR2_X1 $PINS ZN=n_1302 A1=n_16 A2=n_18
Xi_936 OAI21_X1 $PINS ZN=n_1279 A=n_1348 B1=n_1325 B2=n_1302
Xi_935 OAI221_X1 $PINS ZN=n_1272 A=n_1279 B1=n_26 B2=n_28 C1=n_38 C2=n_40
Xi_934 OAI222_X1 $PINS ZN=n_1256 A1=n_86 A2=n_88 B1=n_106 B2=n_108 C1=n_128
+ C2=n_130
Xi_933 OAI22_X1 $PINS ZN=n_1249 A1=n_68 A2=n_70 B1=n_52 B2=n_54
Xi_932 AOI211_X1 $PINS ZN=n_1233 A=n_1256 B=n_1249 C1=n_1490 C2=n_1272
Xi_927 AOI22_X1 $PINS ZN=n_1226 A1=n_68 A2=n_70 B1=n_86 B2=n_88
Xi_926 OAI211_X1 $PINS ZN=n_1210 A=n_106 B=n_108 C1=n_128 C2=n_130
Xi_925 AOI21_X1 $PINS ZN=n_1187 A=n_1233 B1=n_128 B2=n_130
Xi_924 OAI211_X1 $PINS ZN=n_1164 A=n_1210 B=n_1187 C1=n_1256 C2=n_1226
Xi_923 NOR2_X1 $PINS ZN=n_1011 A1=n_236 A2=n_238
Xi_922 OAI222_X1 $PINS ZN=n_1010 A1=n_178 A2=n_180 B1=n_206 B2=n_208 C1=n_236
+ C2=n_238
Xi_921 INV_X1 $PINS ZN=n_1009 A=n_1010
Xi_920 OAI211_X1 $PINS ZN=n_1008 A=n_1009 B=n_1164 C1=n_152 C2=n_154
Xi_919 AOI22_X1 $PINS ZN=n_1007 A1=n_152 A2=n_154 B1=n_178 B2=n_180
Xi_918 AOI22_X1 $PINS ZN=n_1005 A1=n_236 A2=n_238 B1=n_206 B2=n_208
Xi_917 OAI221_X1 $PINS ZN=n_998 A=n_1008 B1=n_1010 B2=n_1007 C1=n_1011
+ C2=n_1005
Xi_916 NOR2_X1 $PINS ZN=n_991 A1=n_304 A2=n_271
Xi_915 NOR2_X2 $PINS ZN=n_990 A1=n_376 A2=n_378
Xi_914 AOI211_X2 $PINS ZN=n_989 A=n_991 B=n_990 C1=n_1621 C2=n_1608
Xi_913 OAI211_X2 $PINS ZN=n_987 A=n_998 B=n_989 C1=n_268 C2=n_270
Xi_912 AOI22_X1 $PINS ZN=n_985 A1=n_268 A2=n_270 B1=n_304 B2=n_271
Xi_911 INV_X1 $PINS ZN=n_983 A=n_985
Xi_910 NOR3_X1 $PINS ZN=n_981 A1=n_1621 A2=n_990 A3=n_1608
Xi_909 AOI221_X2 $PINS ZN=n_979 A=n_981 B1=n_989 B2=n_983 C1=n_376 C2=n_378
Xi_904 NAND2_X1 $PINS ZN=n_977 A1=n_987 A2=n_979
Xi_903 OAI21_X1 $PINS ZN=n_975 A=n_1536 B1=n_1513 B2=n_977
Xi_902 AOI21_X1 $PINS ZN=n_973 A=n_1583 B1=n_1569 B2=n_975
Xi_901 AOI21_X1 $PINS ZN=n_971 A=n_1586 B1=n_775 B2=n_900
Xi_900 OAI22_X1 $PINS ZN=n_968 A1=n_773 A2=n_938 B1=n_1584 B2=n_973
Xi_899 XNOR2_X1 $PINS ZN=Res_imm[24] A=n_971 B=n_968
Xi_898 NOR2_X1 $PINS ZN=n_1451 A1=n_1660 A2=n_1646
Xi_897 NOR2_X1 $PINS ZN=n_1474 A1=n_1659 A2=n_1647
Xi_896 NOR2_X1 $PINS ZN=n_1497 A1=n_1658 A2=n_1648
Xi_895 NOR2_X1 $PINS ZN=n_1382 A1=n_1663 A2=n_1643
Xi_894 NOR2_X1 $PINS ZN=n_1405 A1=n_1662 A2=n_1644
Xi_893 NOR2_X1 $PINS ZN=n_1428 A1=n_1661 A2=n_1645
Xi_892 NOR2_X1 $PINS ZN=n_1313 A1=n_1666 A2=n_1640
Xi_891 NOR2_X1 $PINS ZN=n_1336 A1=n_1665 A2=n_1641
Xi_890 NOR2_X1 $PINS ZN=n_1359 A1=n_1664 A2=n_1642
Xi_889 NOR2_X1 $PINS ZN=n_1430 A1=n_1661 A2=n_1643
Xi_888 NOR2_X1 $PINS ZN=n_1453 A1=n_1660 A2=n_1644
Xi_887 NOR2_X1 $PINS ZN=n_1476 A1=n_1659 A2=n_1645
Xi_886 NOR2_X1 $PINS ZN=n_1361 A1=n_1664 A2=n_1640
Xi_881 NOR2_X1 $PINS ZN=n_1384 A1=n_1663 A2=n_1641
Xi_880 NOR2_X1 $PINS ZN=n_1407 A1=n_1662 A2=n_1642
Xi_879 NOR2_X1 $PINS ZN=n_1292 A1=n_1667 A2=n_1633
Xi_878 NOR2_X1 $PINS ZN=n_1315 A1=n_1666 A2=n_1634
Xi_877 NOR2_X1 $PINS ZN=n_1338 A1=n_1665 A2=n_1639
Xi_876 NOR2_X1 $PINS ZN=n_1544 A1=n_1656 A2=n_1649
Xi_875 NOR2_X1 $PINS ZN=n_1565 A1=n_1655 A2=n_1650
Xi_874 NOR2_X1 $PINS ZN=n_1499 A1=n_1658 A2=n_1646
Xi_873 NOR2_X1 $PINS ZN=n_1522 A1=n_1657 A2=n_1647
Xi_872 NOR2_X1 $PINS ZN=n_1545 A1=n_1656 A2=n_1648
Xi_871 NOR2_X1 $PINS ZN=n_1520 A1=n_1657 A2=n_1649
Xi_870 NOR2_X1 $PINS ZN=n_1543 A1=n_1656 A2=n_1650
Xi_869 NOR2_X1 $PINS ZN=n_1564 A1=n_1655 A2=n_1651
Xi_868 NOR2_X1 $PINS ZN=n_1223 A1=n_1670 A2=n_1630
Xi_867 NOR2_X1 $PINS ZN=n_1246 A1=n_1669 A2=n_1631
Xi_866 NOR2_X1 $PINS ZN=n_1269 A1=n_1668 A2=n_1632
Xi_865 NOR2_X1 $PINS ZN=n_1154 A1=n_1674 A2=n_1625
Xi_864 NOR2_X1 $PINS ZN=n_1177 A1=n_1673 A2=n_1628
Xi_863 NOR2_X1 $PINS ZN=n_1200 A1=n_1672 A2=n_1629
Xi_858 NOR2_X1 $PINS ZN=n_1385 A1=n_1663 A2=n_1640
Xi_857 NOR2_X1 $PINS ZN=n_1408 A1=n_1662 A2=n_1641
Xi_856 NOR2_X1 $PINS ZN=n_1431 A1=n_1661 A2=n_1642
Xi_855 NOR2_X1 $PINS ZN=n_1316 A1=n_1666 A2=n_1633
Xi_854 NOR2_X1 $PINS ZN=n_1339 A1=n_1665 A2=n_1634
Xi_853 NOR2_X1 $PINS ZN=n_1362 A1=n_1664 A2=n_1639
Xi_852 NOR2_X1 $PINS ZN=n_1247 A1=n_1669 A2=n_1630
Xi_851 NOR2_X1 $PINS ZN=n_1270 A1=n_1668 A2=n_1631
Xi_850 NOR2_X1 $PINS ZN=n_1293 A1=n_1667 A2=n_1632
Xi_849 NOR2_X1 $PINS ZN=n_1268 A1=n_1668 A2=n_1633
Xi_848 NOR2_X1 $PINS ZN=n_1291 A1=n_1667 A2=n_1634
Xi_847 NOR2_X1 $PINS ZN=n_1314 A1=n_1666 A2=n_1639
Xi_846 NOR2_X1 $PINS ZN=n_1199 A1=n_1672 A2=n_1630
Xi_845 NOR2_X1 $PINS ZN=n_1222 A1=n_1670 A2=n_1631
Xi_844 NOR2_X1 $PINS ZN=n_1245 A1=n_1669 A2=n_1632
Xi_843 NOR2_X1 $PINS ZN=n_1130 A1=n_1675 A2=n_1625
Xi_842 NOR2_X1 $PINS ZN=n_1153 A1=n_1674 A2=n_1628
Xi_841 NOR2_X1 $PINS ZN=n_1176 A1=n_1673 A2=n_1629
Xi_840 NOR2_X1 $PINS ZN=n_1475 A1=n_1659 A2=n_1646
Xi_835 NOR2_X1 $PINS ZN=n_1498 A1=n_1658 A2=n_1647
Xi_834 NOR2_X1 $PINS ZN=n_1521 A1=n_1657 A2=n_1648
Xi_833 NOR2_X1 $PINS ZN=n_1406 A1=n_1662 A2=n_1643
Xi_832 NOR2_X1 $PINS ZN=n_1429 A1=n_1661 A2=n_1644
Xi_831 NOR2_X1 $PINS ZN=n_1452 A1=n_1660 A2=n_1645
Xi_830 NOR2_X1 $PINS ZN=n_1337 A1=n_1665 A2=n_1640
Xi_829 NOR2_X1 $PINS ZN=n_1360 A1=n_1664 A2=n_1641
Xi_828 NOR2_X1 $PINS ZN=n_1383 A1=n_1663 A2=n_1642
Xi_827 NOR2_X1 $PINS ZN=n_1427 A1=n_1661 A2=n_1646
Xi_826 NOR2_X1 $PINS ZN=n_1450 A1=n_1660 A2=n_1647
Xi_825 NOR2_X1 $PINS ZN=n_1473 A1=n_1659 A2=n_1648
Xi_824 NOR2_X1 $PINS ZN=n_1358 A1=n_1664 A2=n_1643
Xi_823 NOR2_X1 $PINS ZN=n_1381 A1=n_1663 A2=n_1644
Xi_822 NOR2_X1 $PINS ZN=n_1404 A1=n_1662 A2=n_1645
Xi_821 NOR2_X1 $PINS ZN=n_1289 A1=n_1667 A2=n_1640
Xi_820 NOR2_X1 $PINS ZN=n_1312 A1=n_1666 A2=n_1641
Xi_819 NOR2_X1 $PINS ZN=n_1335 A1=n_1665 A2=n_1642
Xi_818 NOR2_X1 $PINS ZN=n_1220 A1=n_1670 A2=n_1633
Xi_817 NOR2_X1 $PINS ZN=n_1243 A1=n_1669 A2=n_1634
Xi_814 NOR2_X1 $PINS ZN=n_1266 A1=n_1668 A2=n_1639
Xi_812 NOR2_X1 $PINS ZN=n_1496 A1=n_1658 A2=n_1649
Xi_811 NOR2_X1 $PINS ZN=n_1519 A1=n_1657 A2=n_1650
Xi_810 NOR2_X1 $PINS ZN=n_1542 A1=n_1656 A2=n_1651
Xi_809 NOR2_X1 $PINS ZN=n_1151 A1=n_1674 A2=n_1630
Xi_808 NOR2_X1 $PINS ZN=n_1174 A1=n_1673 A2=n_1631
Xi_807 NOR2_X1 $PINS ZN=n_1197 A1=n_1672 A2=n_1632
Xi_806 NOR2_X1 $PINS ZN=n_1082 A1=n_1677 A2=n_1625
Xi_805 NOR2_X1 $PINS ZN=n_1105 A1=n_1676 A2=n_1628
Xi_804 NOR2_X1 $PINS ZN=n_1128 A1=n_1675 A2=n_1629
Xi_803 NOR2_X1 $PINS ZN=n_1175 A1=n_1673 A2=n_1630
Xi_802 NOR2_X1 $PINS ZN=n_1198 A1=n_1672 A2=n_1631
Xi_801 NOR2_X1 $PINS ZN=n_1221 A1=n_1670 A2=n_1632
Xi_800 NOR2_X1 $PINS ZN=n_1106 A1=n_1676 A2=n_1625
Xi_799 NOR2_X1 $PINS ZN=n_1129 A1=n_1675 A2=n_1628
Xi_798 NOR2_X1 $PINS ZN=n_1152 A1=n_1674 A2=n_1629
Xi_797 NOR2_X1 $PINS ZN=n_1178 A1=n_1673 A2=n_1625
Xi_796 NOR2_X1 $PINS ZN=n_1201 A1=n_1672 A2=n_1628
Xi_795 NOR2_X1 $PINS ZN=n_1224 A1=n_1670 A2=n_1629
Xi_794 NOR2_X1 $PINS ZN=n_1478 A1=n_1659 A2=n_1643
Xi_793 NOR2_X1 $PINS ZN=n_1501 A1=n_1658 A2=n_1644
Xi_791 NOR2_X1 $PINS ZN=n_1524 A1=n_1657 A2=n_1645
Xi_789 NOR2_X1 $PINS ZN=n_1409 A1=n_1662 A2=n_1640
Xi_788 NOR2_X1 $PINS ZN=n_1432 A1=n_1661 A2=n_1641
Xi_787 NOR2_X1 $PINS ZN=n_1455 A1=n_1660 A2=n_1642
Xi_786 NOR2_X1 $PINS ZN=n_1340 A1=n_1665 A2=n_1633
Xi_785 NOR2_X1 $PINS ZN=n_1363 A1=n_1664 A2=n_1634
Xi_784 NOR2_X1 $PINS ZN=n_1386 A1=n_1663 A2=n_1639
Xi_783 NOR2_X1 $PINS ZN=n_1244 A1=n_1669 A2=n_1633
Xi_782 NOR2_X1 $PINS ZN=n_1267 A1=n_1668 A2=n_1634
Xi_781 NOR2_X1 $PINS ZN=n_1290 A1=n_1667 A2=n_1639
Xi_780 NOR2_X1 $PINS ZN=n_1566 A1=n_1655 A2=n_1649
Xi_779 NOR2_X1 $PINS ZN=n_1523 A1=n_1657 A2=n_1646
Xi_778 NOR2_X1 $PINS ZN=n_1546 A1=n_1656 A2=n_1647
Xi_777 NOR2_X1 $PINS ZN=n_1567 A1=n_1655 A2=n_1648
Xi_776 NOR2_X1 $PINS ZN=n_1454 A1=n_1660 A2=n_1643
Xi_775 NOR2_X1 $PINS ZN=n_1477 A1=n_1659 A2=n_1644
Xi_774 NOR2_X1 $PINS ZN=n_1500 A1=n_1658 A2=n_1645
Xi_773 NOR2_X1 $PINS ZN=n_1563 A1=n_1655 A2=n_1652
Xi_772 NOR2_X1 $PINS ZN=n_1541 A1=n_1656 A2=n_1652
Xi_771 NOR2_X1 $PINS ZN=n_1562 A1=n_1655 A2=n_1653
Xi_770 NOR2_X1 $PINS ZN=n_1265 A1=n_1668 A2=n_1640
Xi_769 NOR2_X1 $PINS ZN=n_1288 A1=n_1667 A2=n_1641
Xi_768 NOR2_X1 $PINS ZN=n_1311 A1=n_1666 A2=n_1642
Xi_766 NOR2_X1 $PINS ZN=n_1196 A1=n_1672 A2=n_1633
Xi_765 NOR2_X1 $PINS ZN=n_1219 A1=n_1670 A2=n_1634
Xi_764 NOR2_X1 $PINS ZN=n_1242 A1=n_1669 A2=n_1639
Xi_763 NOR2_X1 $PINS ZN=n_1127 A1=n_1675 A2=n_1630
Xi_762 NOR2_X1 $PINS ZN=n_1150 A1=n_1674 A2=n_1631
Xi_761 NOR2_X1 $PINS ZN=n_1173 A1=n_1673 A2=n_1632
Xi_760 NOR2_X1 $PINS ZN=n_1472 A1=n_1659 A2=n_1649
Xi_759 NOR2_X1 $PINS ZN=n_1495 A1=n_1658 A2=n_1650
Xi_758 NOR2_X1 $PINS ZN=n_1518 A1=n_1657 A2=n_1651
Xi_757 NOR2_X1 $PINS ZN=n_1403 A1=n_1662 A2=n_1646
Xi_756 NOR2_X1 $PINS ZN=n_1426 A1=n_1661 A2=n_1647
Xi_755 NOR2_X1 $PINS ZN=n_1449 A1=n_1660 A2=n_1648
Xi_754 NOR2_X1 $PINS ZN=n_1334 A1=n_1665 A2=n_1643
Xi_753 NOR2_X1 $PINS ZN=n_1357 A1=n_1664 A2=n_1644
Xi_752 NOR2_X1 $PINS ZN=n_1380 A1=n_1663 A2=n_1645
Xi_751 NOR2_X1 $PINS ZN=n_1058 A1=n_1678 A2=n_1625
Xi_750 NOR2_X1 $PINS ZN=n_1081 A1=n_1677 A2=n_1628
Xi_749 NOR2_X1 $PINS ZN=n_1104 A1=n_1676 A2=n_1629
Xi_748 NOR2_X1 $PINS ZN=n_1172 A1=n_1673 A2=n_1633
Xi_747 NOR2_X1 $PINS ZN=n_1195 A1=n_1672 A2=n_1634
Xi_746 NOR2_X1 $PINS ZN=n_1218 A1=n_1670 A2=n_1639
Xi_745 NOR2_X1 $PINS ZN=n_1103 A1=n_1676 A2=n_1630
Xi_743 NOR2_X1 $PINS ZN=n_1126 A1=n_1675 A2=n_1631
Xi_742 NOR2_X1 $PINS ZN=n_1149 A1=n_1674 A2=n_1632
Xi_741 NOR2_X1 $PINS ZN=n_1034 A1=n_1654 A2=n_1625
Xi_740 NOR2_X1 $PINS ZN=n_1057 A1=n_1678 A2=n_1628
Xi_739 NOR2_X1 $PINS ZN=n_1080 A1=n_1677 A2=n_1629
Xi_738 NOR2_X1 $PINS ZN=n_1379 A1=n_1663 A2=n_1646
Xi_737 NOR2_X1 $PINS ZN=n_1402 A1=n_1662 A2=n_1647
Xi_736 NOR2_X1 $PINS ZN=n_1425 A1=n_1661 A2=n_1648
Xi_735 NOR2_X1 $PINS ZN=n_1310 A1=n_1666 A2=n_1643
Xi_734 NOR2_X1 $PINS ZN=n_1333 A1=n_1665 A2=n_1644
Xi_733 NOR2_X1 $PINS ZN=n_1356 A1=n_1664 A2=n_1645
Xi_732 NOR2_X1 $PINS ZN=n_1241 A1=n_1669 A2=n_1640
Xi_731 NOR2_X1 $PINS ZN=n_1264 A1=n_1668 A2=n_1641
Xi_730 NOR2_X1 $PINS ZN=n_1287 A1=n_1667 A2=n_1642
Xi_729 NOR2_X1 $PINS ZN=n_1517 A1=n_1657 A2=n_1652
Xi_728 NOR2_X1 $PINS ZN=n_1540 A1=n_1656 A2=n_1653
Xi_727 NOR2_X1 $PINS ZN=n_1561 A1=n_1655 A2=n_1654
Xi_726 NOR2_X1 $PINS ZN=n_1448 A1=n_1660 A2=n_1649
Xi_725 NOR2_X1 $PINS ZN=n_1471 A1=n_1659 A2=n_1650
Xi_724 NOR2_X1 $PINS ZN=n_1494 A1=n_1658 A2=n_1651
Xi_723 NOR2_X1 $PINS ZN=n_1102 A1=n_1676 A2=n_1631
Xi_722 NOR2_X1 $PINS ZN=n_1125 A1=n_1675 A2=n_1632
Xi_721 NOR2_X1 $PINS ZN=n_1148 A1=n_1674 A2=n_1633
Xi_720 NOR2_X1 $PINS ZN=n_1033 A1=n_1654 A2=n_1628
Xi_719 NOR2_X1 $PINS ZN=n_1056 A1=n_1678 A2=n_1629
Xi_718 NOR2_X1 $PINS ZN=n_1079 A1=n_1677 A2=n_1630
Xi_717 NOR2_X1 $PINS ZN=n_1309 A1=n_1666 A2=n_1644
Xi_716 NOR2_X1 $PINS ZN=n_1332 A1=n_1665 A2=n_1645
Xi_715 NOR2_X1 $PINS ZN=n_1355 A1=n_1664 A2=n_1646
Xi_714 NOR2_X1 $PINS ZN=n_1240 A1=n_1669 A2=n_1641
Xi_713 NOR2_X1 $PINS ZN=n_1263 A1=n_1668 A2=n_1642
Xi_712 NOR2_X1 $PINS ZN=n_1286 A1=n_1667 A2=n_1643
Xi_711 NOR2_X1 $PINS ZN=n_1171 A1=n_1673 A2=n_1634
Xi_710 NOR2_X1 $PINS ZN=n_1194 A1=n_1672 A2=n_1639
Xi_709 NOR2_X1 $PINS ZN=n_1217 A1=n_1670 A2=n_1640
Xi_708 NOR2_X1 $PINS ZN=n_1516 A1=n_1657 A2=n_1653
Xi_707 NOR2_X1 $PINS ZN=n_1539 A1=n_1656 A2=n_1654
Xi_706 NOR2_X1 $PINS ZN=n_1447 A1=n_1660 A2=n_1650
Xi_705 NOR2_X1 $PINS ZN=n_1470 A1=n_1659 A2=n_1651
Xi_704 NOR2_X1 $PINS ZN=n_1493 A1=n_1658 A2=n_1652
Xi_703 NOR2_X1 $PINS ZN=n_1378 A1=n_1663 A2=n_1647
Xi_702 NOR2_X1 $PINS ZN=n_1401 A1=n_1662 A2=n_1648
Xi_701 NOR2_X1 $PINS ZN=n_1424 A1=n_1661 A2=n_1649
Xi_700 NOR2_X1 $PINS ZN=n_1271 A1=n_1668 A2=n_1630
Xi_699 NOR2_X1 $PINS ZN=n_1294 A1=n_1667 A2=n_1631
Xi_698 NOR2_X1 $PINS ZN=n_1317 A1=n_1666 A2=n_1632
Xi_697 NOR2_X1 $PINS ZN=n_1202 A1=n_1672 A2=n_1625
Xi_696 NOR2_X1 $PINS ZN=n_1225 A1=n_1670 A2=n_1628
Xi_695 NOR2_X1 $PINS ZN=n_1248 A1=n_1669 A2=n_1629
Xi_694 NOR2_X1 $PINS ZN=n_1433 A1=n_1661 A2=n_1640
Xi_693 NOR2_X1 $PINS ZN=n_1456 A1=n_1660 A2=n_1641
Xi_692 NOR2_X1 $PINS ZN=n_1479 A1=n_1659 A2=n_1642
Xi_691 NOR2_X1 $PINS ZN=n_1364 A1=n_1664 A2=n_1633
Xi_690 NOR2_X1 $PINS ZN=n_1387 A1=n_1663 A2=n_1634
Xi_689 NOR2_X1 $PINS ZN=n_1410 A1=n_1662 A2=n_1639
Xi_688 NOR2_X1 $PINS ZN=n_1295 A1=n_1667 A2=n_1630
Xi_687 NOR2_X1 $PINS ZN=n_1318 A1=n_1666 A2=n_1631
Xi_686 NOR2_X1 $PINS ZN=n_1341 A1=n_1665 A2=n_1632
Xi_685 NOR2_X1 $PINS ZN=n_1547 A1=n_1656 A2=n_1646
Xi_684 NOR2_X1 $PINS ZN=n_1568 A1=n_1655 A2=n_1647
Xi_683 NOR2_X1 $PINS ZN=n_1502 A1=n_1658 A2=n_1643
Xi_682 NOR2_X1 $PINS ZN=n_1525 A1=n_1657 A2=n_1644
Xi_681 NOR2_X1 $PINS ZN=n_1548 A1=n_1656 A2=n_1645
Xi_680 HA_X1 $PINS CO=n_11 S=n_955 A=n_3 B=n_6
Xi_679 FA_X1 $PINS CO=n_7 S=n_954 A=n_737 B=n_738 CI=n_739
Xi_678 HA_X1 $PINS CO=n_19 S=n_18 A=n_9 B=n_11
Xi_677 FA_X1 $PINS CO=n_17 S=n_16 A=n_7 B=n_8 CI=n_10
Xi_676 HA_X1 $PINS CO=n_29 S=n_28 A=n_19 B=n_17
Xi_675 FA_X1 $PINS CO=n_27 S=n_26 A=n_14 B=n_12 CI=n_20
Xi_674 HA_X1 $PINS CO=n_55 S=n_54 A=n_39 B=n_37
Xi_673 FA_X1 $PINS CO=n_53 S=n_52 A=n_36 B=n_32 CI=n_41
Xi_672 HA_X1 $PINS CO=n_41 S=n_40 A=n_30 B=n_27
Xi_671 FA_X1 $PINS CO=n_39 S=n_38 A=n_24 B=n_22 CI=n_29
Xi_670 HA_X1 $PINS CO=n_71 S=n_70 A=n_55 B=n_53
Xi_669 FA_X1 $PINS CO=n_69 S=n_68 A=n_48 B=n_50 CI=n_51
Xi_668 HA_X1 $PINS CO=n_89 S=n_88 A=n_71 B=n_69
Xi_667 FA_X1 $PINS CO=n_87 S=n_86 A=n_64 B=n_79 CI=n_82
Xi_666 HA_X1 $PINS CO=n_131 S=n_130 A=n_107 B=n_109
Xi_665 HA_X1 $PINS CO=n_109 S=n_108 A=n_89 B=n_87
Xi_664 FA_X1 $PINS CO=n_107 S=n_106 A=n_102 B=n_100 CI=n_104
Xi_663 FA_X1 $PINS CO=n_145 S=n_144 A=n_116 B=n_136 CI=n_134
Xi_662 FA_X1 $PINS CO=n_147 S=n_146 A=n_132 B=n_119 CI=n_118
Xi_661 FA_X1 $PINS CO=n_129 S=n_128 A=n_105 B=n_124 CI=n_126
Xi_660 FA_X1 $PINS CO=n_125 S=n_124 A=n_98 B=n_120 CI=n_115
Xi_659 FA_X1 $PINS CO=n_105 S=n_104 A=n_94 B=n_81 CI=n_83
Xi_658 FA_X1 $PINS CO=n_127 S=n_126 A=n_101 B=n_103 CI=n_122
Xi_657 FA_X1 $PINS CO=n_103 S=n_102 A=n_90 B=n_84 CI=n_67
Xi_656 FA_X1 $PINS CO=n_101 S=n_100 A=n_66 B=n_93 CI=n_92
Xi_655 FA_X1 $PINS CO=n_123 S=n_122 A=n_114 B=n_112 CI=n_110
Xi_654 FA_X1 $PINS CO=n_939 S=n_142 A=n_113 B=n_111 CI=n_99
Xi_653 FA_X1 $PINS CO=n_121 S=n_120 A=n_91 B=n_85 CI=n_96
Xi_652 HA_X1 $PINS CO=n_181 S=n_180 A=n_153 B=n_155
Xi_651 HA_X1 $PINS CO=n_155 S=n_154 A=n_150 B=n_131
Xi_650 FA_X1 $PINS CO=n_153 S=n_152 A=n_148 B=n_127 CI=n_129
Xi_649 FA_X1 $PINS CO=n_179 S=n_178 A=n_174 B=n_151 CI=n_176
Xi_648 FA_X1 $PINS CO=n_151 S=n_150 A=n_125 B=n_146 CI=n_144
Xi_647 FA_X1 $PINS CO=n_201 S=n_200 A=n_166 B=n_194 CI=n_192
Xi_646 FA_X1 $PINS CO=n_175 S=n_174 A=n_147 B=n_145 CI=n_165
Xi_645 FA_X1 $PINS CO=n_197 S=n_196 A=n_164 B=n_190 CI=n_188
Xi_644 FA_X1 $PINS CO=n_203 S=n_202 A=n_171 B=n_173 CI=n_198
Xi_643 FA_X1 $PINS CO=n_199 S=n_198 A=n_186 B=n_184 CI=n_182
Xi_642 FA_X1 $PINS CO=n_177 S=n_176 A=n_149 B=n_172 CI=n_170
Xi_641 FA_X1 $PINS CO=n_171 S=n_170 A=n_161 B=n_159 CI=n_157
Xi_640 FA_X1 $PINS CO=n_173 S=n_172 A=n_143 B=n_138 CI=n_163
Xi_639 FA_X1 $PINS CO=n_149 S=n_148 A=n_121 B=n_142 CI=n_123
Xi_638 HA_X1 $PINS CO=n_271 S=n_270 A=n_237 B=n_239
Xi_637 HA_X1 $PINS CO=n_239 S=n_238 A=n_207 B=n_209
Xi_636 HA_X1 $PINS CO=n_209 S=n_208 A=n_179 B=n_181
Xi_635 FA_X1 $PINS CO=n_207 S=n_206 A=n_177 B=n_202 CI=n_204
Xi_634 FA_X1 $PINS CO=n_237 S=n_236 A=n_232 B=n_205 CI=n_234
Xi_633 FA_X1 $PINS CO=n_205 S=n_204 A=n_196 B=n_175 CI=n_200
Xi_632 HA_X1 $PINS CO=n_305 S=n_304 A=n_269 B=n_302
Xi_631 FA_X1 $PINS CO=n_269 S=n_268 A=n_235 B=n_264 CI=n_266
Xi_630 FA_X1 $PINS CO=n_235 S=n_234 A=n_226 B=n_230 CI=n_203
Xi_629 HA_X1 $PINS CO=n_379 S=n_378 A=n_339 B=n_341
Xi_628 HA_X1 $PINS CO=n_341 S=n_340 A=n_303 B=n_338
Xi_627 FA_X1 $PINS CO=n_303 S=n_302 A=n_267 B=n_298 CI=n_300
Xi_626 FA_X1 $PINS CO=n_267 S=n_266 A=n_260 B=n_262 CI=n_233
Xi_625 FA_X1 $PINS CO=n_233 S=n_232 A=n_224 B=n_201 CI=n_228
Xi_624 FA_X1 $PINS CO=n_339 S=n_338 A=n_334 B=n_301 CI=n_336
Xi_623 FA_X1 $PINS CO=n_301 S=n_300 A=n_294 B=n_265 CI=n_296
Xi_622 FA_X1 $PINS CO=n_265 S=n_264 A=n_231 B=n_258 CI=n_256
Xi_621 FA_X1 $PINS CO=n_231 S=n_230 A=n_222 B=n_199 CI=n_197
Xi_620 HA_X1 $PINS CO=n_419 S=n_418 A=n_377 B=n_416
Xi_619 FA_X1 $PINS CO=n_377 S=n_376 A=n_337 B=n_372 CI=n_374
Xi_618 FA_X1 $PINS CO=n_337 S=n_336 A=n_330 B=n_299 CI=n_332
Xi_617 FA_X1 $PINS CO=n_299 S=n_298 A=n_261 B=n_292 CI=n_290
Xi_616 FA_X1 $PINS CO=n_261 S=n_260 A=n_240 B=n_225 CI=n_254
Xi_615 FA_X1 $PINS CO=n_225 S=n_224 A=n_183 B=n_195 CI=n_193
Xi_614 FA_X1 $PINS CO=n_193 S=n_192 A=n_756 B=n_162 CI=n_160
Xi_613 FA_X1 $PINS CO=n_195 S=n_194 A=n_158 B=n_156 CI=n_140
Xi_612 FA_X1 $PINS CO=n_183 S=n_182 A=n_700 B=n_703 CI=n_705
Xi_611 HA_X1 $PINS CO=n_938 S=n_460 A=n_417 B=n_458
Xi_610 FA_X1 $PINS CO=n_417 S=n_416 A=n_375 B=n_412 CI=n_414
Xi_609 FA_X1 $PINS CO=n_375 S=n_374 A=n_333 B=n_335 CI=n_370
Xi_608 FA_X1 $PINS CO=n_335 S=n_334 A=n_326 B=n_324 CI=n_297
Xi_607 FA_X1 $PINS CO=n_297 S=n_296 A=n_257 B=n_288 CI=n_263
Xi_606 FA_X1 $PINS CO=n_263 S=n_262 A=n_252 B=n_229 CI=n_227
Xi_605 FA_X1 $PINS CO=n_227 S=n_226 A=n_220 B=n_218 CI=n_216
Xi_604 FA_X1 $PINS CO=n_229 S=n_228 A=n_214 B=n_212 CI=n_210
Xi_603 FA_X1 $PINS CO=n_257 S=n_256 A=n_221 B=n_250 CI=n_248
Xi_602 FA_X1 $PINS CO=n_221 S=n_220 A=n_1547 B=n_1568 CI=n_191
Xi_601 FA_X1 $PINS CO=n_191 S=n_190 A=n_1502 B=n_1525 CI=n_1548
Xi_600 FA_X1 $PINS CO=n_333 S=n_332 A=n_293 B=n_295 CI=n_328
Xi_599 FA_X1 $PINS CO=n_295 S=n_294 A=n_286 B=n_284 CI=n_259
Xi_598 FA_X1 $PINS CO=n_259 S=n_258 A=n_246 B=n_244 CI=n_242
Xi_597 FA_X1 $PINS CO=n_293 S=n_292 A=n_274 B=n_272 CI=n_255
Xi_596 FA_X1 $PINS CO=n_255 S=n_254 A=n_213 B=n_211 CI=n_223
Xi_595 FA_X1 $PINS CO=n_223 S=n_222 A=n_189 B=n_187 CI=n_185
Xi_594 FA_X1 $PINS CO=n_185 S=n_184 A=n_1295 B=n_1318 CI=n_1341
Xi_593 FA_X1 $PINS CO=n_187 S=n_186 A=n_1364 B=n_1387 CI=n_1410
Xi_592 FA_X1 $PINS CO=n_189 S=n_188 A=n_1433 B=n_1456 CI=n_1479
Xi_591 FA_X1 $PINS CO=n_211 S=n_210 A=n_1202 B=n_1225 CI=n_1248
Xi_590 FA_X1 $PINS CO=n_213 S=n_212 A=n_1271 B=n_1294 CI=n_1317
Xi_589 HA_X1 $PINS CO=n_921 S=n_900 A=n_503 B=n_546
Xi_588 FA_X1 $PINS CO=n_879 S=n_546 A=n_542 B=n_501 CI=n_544
Xi_587 FA_X1 $PINS CO=n_878 S=n_544 A=n_499 B=n_538 CI=n_540
Xi_586 FA_X1 $PINS CO=n_855 S=n_540 A=n_528 B=n_493 CI=n_536
Xi_585 FA_X1 $PINS CO=n_854 S=n_536 A=n_487 B=n_485 CI=n_526
Xi_584 FA_X1 $PINS CO=n_829 S=n_526 A=n_463 B=n_481 CI=n_479
Xi_583 FA_X1 $PINS CO=n_828 S=n_528 A=n_520 B=n_518 CI=n_516
Xi_582 FA_X1 $PINS CO=n_801 S=n_516 A=n_1378 B=n_1401 CI=n_1424
Xi_581 FA_X1 $PINS CO=n_800 S=n_518 A=n_1447 B=n_1470 CI=n_1493
Xi_580 FA_X1 $PINS CO=n_793 S=n_520 A=n_1516 B=n_1539 CI=n_477
Xi_579 FA_X1 $PINS CO=n_792 S=n_538 A=n_491 B=n_532 CI=n_530
Xi_578 FA_X1 $PINS CO=n_791 S=n_530 A=n_514 B=n_512 CI=n_510
Xi_577 FA_X1 $PINS CO=n_790 S=n_510 A=n_1171 B=n_1194 CI=n_1217
Xi_576 FA_X1 $PINS CO=n_789 S=n_512 A=n_1240 B=n_1263 CI=n_1286
Xi_575 FA_X1 $PINS CO=n_788 S=n_514 A=n_1309 B=n_1332 CI=n_1355
Xi_574 FA_X1 $PINS CO=n_787 S=n_532 A=n_508 B=n_506 CI=n_483
Xi_573 FA_X1 $PINS CO=n_786 S=n_506 A=n_1033 B=n_1056 CI=n_1079
Xi_572 FA_X1 $PINS CO=n_785 S=n_508 A=n_1102 B=n_1125 CI=n_1148
Xi_571 FA_X1 $PINS CO=n_783 S=n_542 A=n_534 B=n_495 CI=n_497
Xi_570 FA_X1 $PINS CO=n_780 S=n_534 A=n_524 B=n_522 CI=n_489
Xi_569 FA_X1 $PINS CO=n_778 S=n_522 A=n_475 B=n_473 CI=n_471
Xi_568 FA_X1 $PINS CO=n_776 S=n_524 A=n_469 B=n_467 CI=n_465
Xi_567 HA_X1 $PINS CO=n_775 S=n_773 A=n_459 B=n_502
Xi_566 FA_X1 $PINS CO=n_503 S=n_502 A=n_498 B=n_457 CI=n_500
Xi_565 FA_X1 $PINS CO=n_501 S=n_500 A=n_494 B=n_455 CI=n_496
Xi_564 FA_X1 $PINS CO=n_497 S=n_496 A=n_486 B=n_484 CI=n_451
Xi_563 FA_X1 $PINS CO=n_485 S=n_484 A=n_435 B=n_476 CI=n_474
Xi_562 FA_X1 $PINS CO=n_475 S=n_474 A=n_1448 B=n_1471 CI=n_1494
Xi_561 FA_X1 $PINS CO=n_477 S=n_476 A=n_1517 B=n_1540 CI=n_1561
Xi_560 FA_X1 $PINS CO=n_487 S=n_486 A=n_472 B=n_470 CI=n_468
Xi_559 FA_X1 $PINS CO=n_469 S=n_468 A=n_1241 B=n_1264 CI=n_1287
Xi_558 FA_X1 $PINS CO=n_471 S=n_470 A=n_1310 B=n_1333 CI=n_1356
Xi_557 FA_X1 $PINS CO=n_473 S=n_472 A=n_1379 B=n_1402 CI=n_1425
Xi_556 FA_X1 $PINS CO=n_495 S=n_494 A=n_449 B=n_447 CI=n_488
Xi_555 FA_X1 $PINS CO=n_489 S=n_488 A=n_466 B=n_464 CI=n_462
Xi_554 FA_X1 $PINS CO=n_463 S=n_462 A=n_1034 B=n_1057 CI=n_1080
Xi_553 FA_X1 $PINS CO=n_465 S=n_464 A=n_1103 B=n_1126 CI=n_1149
Xi_552 FA_X1 $PINS CO=n_467 S=n_466 A=n_1172 B=n_1195 CI=n_1218
Xi_551 FA_X1 $PINS CO=n_499 S=n_498 A=n_492 B=n_490 CI=n_453
Xi_550 FA_X1 $PINS CO=n_491 S=n_490 A=n_480 B=n_478 CI=n_445
Xi_549 FA_X1 $PINS CO=n_479 S=n_478 A=n_433 B=n_431 CI=n_429
Xi_548 FA_X1 $PINS CO=n_481 S=n_480 A=n_427 B=n_425 CI=n_423
Xi_547 FA_X1 $PINS CO=n_493 S=n_492 A=n_443 B=n_441 CI=n_482
Xi_546 FA_X1 $PINS CO=n_483 S=n_482 A=n_421 B=n_439 CI=n_437
Xi_545 FA_X1 $PINS CO=n_459 S=n_458 A=n_454 B=n_415 CI=n_456
Xi_544 FA_X1 $PINS CO=n_457 S=n_456 A=n_450 B=n_413 CI=n_452
Xi_543 FA_X1 $PINS CO=n_453 S=n_452 A=n_444 B=n_442 CI=n_446
Xi_542 FA_X1 $PINS CO=n_447 S=n_446 A=n_420 B=n_399 CI=n_438
Xi_541 FA_X1 $PINS CO=n_439 S=n_438 A=n_385 B=n_383 CI=n_381
Xi_540 FA_X1 $PINS CO=n_421 S=n_420 A=n_1058 B=n_1081 CI=n_1104
Xi_539 FA_X1 $PINS CO=n_443 S=n_442 A=n_432 B=n_430 CI=n_428
Xi_538 FA_X1 $PINS CO=n_429 S=n_428 A=n_1334 B=n_1357 CI=n_1380
Xi_537 FA_X1 $PINS CO=n_431 S=n_430 A=n_1403 B=n_1426 CI=n_1449
Xi_536 FA_X1 $PINS CO=n_433 S=n_432 A=n_1472 B=n_1495 CI=n_1518
Xi_535 FA_X1 $PINS CO=n_445 S=n_444 A=n_426 B=n_424 CI=n_422
Xi_534 FA_X1 $PINS CO=n_423 S=n_422 A=n_1127 B=n_1150 CI=n_1173
Xi_533 FA_X1 $PINS CO=n_425 S=n_424 A=n_1196 B=n_1219 CI=n_1242
Xi_532 FA_X1 $PINS CO=n_427 S=n_426 A=n_1265 B=n_1288 CI=n_1311
Xi_531 FA_X1 $PINS CO=n_413 S=n_412 A=n_369 B=n_408 CI=n_406
Xi_530 FA_X1 $PINS CO=n_451 S=n_450 A=n_440 B=n_407 CI=n_405
Xi_529 FA_X1 $PINS CO=n_407 S=n_406 A=n_396 B=n_394 CI=n_365
Xi_528 FA_X1 $PINS CO=n_441 S=n_440 A=n_397 B=n_395 CI=n_434
Xi_527 FA_X1 $PINS CO=n_435 S=n_434 A=n_1541 B=n_1562 CI=n_393
Xi_526 FA_X1 $PINS CO=n_395 S=n_394 A=n_1563 B=n_355 CI=n_353
Xi_525 FA_X1 $PINS CO=n_397 S=n_396 A=n_351 B=n_349 CI=n_347
Xi_524 FA_X1 $PINS CO=n_415 S=n_414 A=n_371 B=n_373 CI=n_410
Xi_523 FA_X1 $PINS CO=n_373 S=n_372 A=n_362 B=n_368 CI=n_366
Xi_522 FA_X1 $PINS CO=n_369 S=n_368 A=n_327 B=n_325 CI=n_360
Xi_521 FA_X1 $PINS CO=n_325 S=n_324 A=n_285 B=n_318 CI=n_316
Xi_520 FA_X1 $PINS CO=n_285 S=n_284 A=n_1566 B=n_251 CI=n_249
Xi_519 FA_X1 $PINS CO=n_249 S=n_248 A=n_1454 B=n_1477 CI=n_1500
Xi_518 FA_X1 $PINS CO=n_251 S=n_250 A=n_1523 B=n_1546 CI=n_1567
Xi_517 FA_X1 $PINS CO=n_327 S=n_326 A=n_314 B=n_312 CI=n_310
Xi_516 FA_X1 $PINS CO=n_371 S=n_370 A=n_331 B=n_329 CI=n_364
Xi_515 FA_X1 $PINS CO=n_365 S=n_364 A=n_346 B=n_344 CI=n_342
Xi_514 FA_X1 $PINS CO=n_347 S=n_346 A=n_1244 B=n_1267 CI=n_1290
Xi_513 FA_X1 $PINS CO=n_329 S=n_328 A=n_308 B=n_306 CI=n_322
Xi_512 FA_X1 $PINS CO=n_331 S=n_330 A=n_320 B=n_291 CI=n_289
Xi_511 FA_X1 $PINS CO=n_289 S=n_288 A=n_241 B=n_253 CI=n_282
Xi_510 FA_X1 $PINS CO=n_253 S=n_252 A=n_219 B=n_217 CI=n_215
Xi_509 FA_X1 $PINS CO=n_215 S=n_214 A=n_1340 B=n_1363 CI=n_1386
Xi_508 FA_X1 $PINS CO=n_217 S=n_216 A=n_1409 B=n_1432 CI=n_1455
Xi_507 FA_X1 $PINS CO=n_219 S=n_218 A=n_1478 B=n_1501 CI=n_1524
Xi_506 FA_X1 $PINS CO=n_241 S=n_240 A=n_1178 B=n_1201 CI=n_1224
Xi_505 FA_X1 $PINS CO=n_291 S=n_290 A=n_280 B=n_278 CI=n_276
Xi_504 FA_X1 $PINS CO=n_455 S=n_454 A=n_409 B=n_448 CI=n_411
Xi_503 FA_X1 $PINS CO=n_411 S=n_410 A=n_404 B=n_402 CI=n_400
Xi_502 FA_X1 $PINS CO=n_405 S=n_404 A=n_382 B=n_380 CI=n_398
Xi_501 FA_X1 $PINS CO=n_399 S=n_398 A=n_345 B=n_343 CI=n_359
Xi_500 FA_X1 $PINS CO=n_343 S=n_342 A=n_1106 B=n_1129 CI=n_1152
Xi_499 FA_X1 $PINS CO=n_345 S=n_344 A=n_1175 B=n_1198 CI=n_1221
Xi_498 FA_X1 $PINS CO=n_381 S=n_380 A=n_1082 B=n_1105 CI=n_1128
Xi_497 FA_X1 $PINS CO=n_383 S=n_382 A=n_1151 B=n_1174 CI=n_1197
Xi_496 FA_X1 $PINS CO=n_449 S=n_448 A=n_436 B=n_403 CI=n_401
Xi_495 FA_X1 $PINS CO=n_401 S=n_400 A=n_357 B=n_392 CI=n_390
Xi_494 FA_X1 $PINS CO=n_393 S=n_392 A=n_1496 B=n_1519 CI=n_1542
Xi_493 FA_X1 $PINS CO=n_403 S=n_402 A=n_388 B=n_386 CI=n_384
Xi_492 FA_X1 $PINS CO=n_385 S=n_384 A=n_1220 B=n_1243 CI=n_1266
Xi_491 FA_X1 $PINS CO=n_437 S=n_436 A=n_391 B=n_389 CI=n_387
Xi_490 FA_X1 $PINS CO=n_387 S=n_386 A=n_1289 B=n_1312 CI=n_1335
Xi_489 FA_X1 $PINS CO=n_389 S=n_388 A=n_1358 B=n_1381 CI=n_1404
Xi_488 FA_X1 $PINS CO=n_391 S=n_390 A=n_1427 B=n_1450 CI=n_1473
Xi_487 FA_X1 $PINS CO=n_409 S=n_408 A=n_363 B=n_361 CI=n_367
Xi_486 FA_X1 $PINS CO=n_367 S=n_366 A=n_323 B=n_358 CI=n_356
Xi_485 FA_X1 $PINS CO=n_357 S=n_356 A=n_317 B=n_315 CI=n_313
Xi_484 FA_X1 $PINS CO=n_313 S=n_312 A=n_1337 B=n_1360 CI=n_1383
Xi_483 FA_X1 $PINS CO=n_315 S=n_314 A=n_1406 B=n_1429 CI=n_1452
Xi_482 FA_X1 $PINS CO=n_317 S=n_316 A=n_1475 B=n_1498 CI=n_1521
Xi_481 FA_X1 $PINS CO=n_359 S=n_358 A=n_311 B=n_309 CI=n_307
Xi_480 FA_X1 $PINS CO=n_307 S=n_306 A=n_1130 B=n_1153 CI=n_1176
Xi_479 FA_X1 $PINS CO=n_309 S=n_308 A=n_1199 B=n_1222 CI=n_1245
Xi_478 FA_X1 $PINS CO=n_311 S=n_310 A=n_1268 B=n_1291 CI=n_1314
Xi_477 FA_X1 $PINS CO=n_323 S=n_322 A=n_275 B=n_273 CI=n_287
Xi_476 FA_X1 $PINS CO=n_287 S=n_286 A=n_247 B=n_245 CI=n_243
Xi_475 FA_X1 $PINS CO=n_243 S=n_242 A=n_1247 B=n_1270 CI=n_1293
Xi_474 FA_X1 $PINS CO=n_245 S=n_244 A=n_1316 B=n_1339 CI=n_1362
Xi_473 FA_X1 $PINS CO=n_247 S=n_246 A=n_1385 B=n_1408 CI=n_1431
Xi_472 FA_X1 $PINS CO=n_273 S=n_272 A=n_1154 B=n_1177 CI=n_1200
Xi_471 FA_X1 $PINS CO=n_275 S=n_274 A=n_1223 B=n_1246 CI=n_1269
Xi_470 FA_X1 $PINS CO=n_361 S=n_360 A=n_321 B=n_319 CI=n_354
Xi_469 FA_X1 $PINS CO=n_355 S=n_354 A=n_1520 B=n_1543 CI=n_1564
Xi_468 FA_X1 $PINS CO=n_319 S=n_318 A=n_1544 B=n_1565 CI=n_283
Xi_467 FA_X1 $PINS CO=n_283 S=n_282 A=n_1499 B=n_1522 CI=n_1545
Xi_466 FA_X1 $PINS CO=n_321 S=n_320 A=n_281 B=n_279 CI=n_277
Xi_465 FA_X1 $PINS CO=n_277 S=n_276 A=n_1292 B=n_1315 CI=n_1338
Xi_464 FA_X1 $PINS CO=n_279 S=n_278 A=n_1361 B=n_1384 CI=n_1407
Xi_463 FA_X1 $PINS CO=n_281 S=n_280 A=n_1430 B=n_1453 CI=n_1476
Xi_462 FA_X1 $PINS CO=n_363 S=n_362 A=n_352 B=n_350 CI=n_348
Xi_461 FA_X1 $PINS CO=n_349 S=n_348 A=n_1313 B=n_1336 CI=n_1359
Xi_460 FA_X1 $PINS CO=n_351 S=n_350 A=n_1382 B=n_1405 CI=n_1428
Xi_459 FA_X1 $PINS CO=n_353 S=n_352 A=n_1451 B=n_1474 CI=n_1497
Xi_458 INV_X1 $PINS ZN=n_1773 A=n_0
Xi_457 INV_X1 $PINS ZN=n_1767 A=n_1813
Xi_456 NAND2_X1 $PINS ZN=n_1765 A1=hfn_ipo_n6 A2=n_1767
Xi_455 NOR2_X2 $PINS ZN=n_1763 A1=n_938 A2=n_773
Xi_454 NOR3_X1 $PINS ZN=n_771 A1=n_1763 A2=n_1586 A3=n_1583
Xi_453 NOR2_X1 $PINS ZN=n_1757 A1=n_1711 A2=n_1706
Xi_452 INV_X1 $PINS ZN=n_1756 A=n_1757
Xi_451 OAI21_X1 $PINS ZN=n_770 A=n_1756 B1=n_1707 B2=n_1704
Xi_450 NOR2_X1 $PINS ZN=n_769 A1=n_1713 A2=n_1708
Xi_449 NOR2_X2 $PINS ZN=n_1750 A1=n_591 A2=n_630
Xi_448 INV_X1 $PINS ZN=n_1749 A=n_1750
Xi_447 NOR2_X1 $PINS ZN=n_1748 A1=n_168 A2=n_1712
Xi_446 INV_X1 $PINS ZN=n_1747 A=n_1748
Xi_445 NAND3_X1 $PINS ZN=n_768 A1=n_1776 A2=n_1747 A3=n_1749
Xi_444 NOR2_X1 $PINS ZN=n_764 A1=n_921 A2=n_590
Xi_443 AND2_X1 $PINS ZN=n_1724 A1=n_2 A2=n_4
Xi_442 NOR2_X1 $PINS ZN=n_1723 A1=n_1656 A2=n_1628
Xi_441 AOI22_X1 $PINS ZN=n_1722 A1=A_imm[2] A2=n_0 B1=A_imm[0] B2=n_1723
Xi_440 AOI211_X1 $PINS ZN=n_1721 A=n_1655 B=n_1722 C1=n_1629 C2=n_1773
Xi_439 OAI222_X1 $PINS ZN=n_763 A1=n_954 A2=n_955 B1=n_2 B2=n_4 C1=n_1724
+ C2=n_1721
Xi_438 INV_X1 $PINS ZN=n_1702 A=n_1569
Xi_437 OAI21_X1 $PINS ZN=n_762 A=n_771 B1=n_1513 B2=n_1702
Xi_436 NAND2_X1 $PINS ZN=n_761 A1=n_1709 A2=n_1710
Xi_435 NAND2_X1 $PINS ZN=n_760 A1=n_921 A2=n_590
Xi_434 NAND2_X1 $PINS ZN=n_758 A1=n_591 A2=n_630
Xi_433 INV_X1 $PINS ZN=n_1689 A=n_758
Xi_432 INV_X1 $PINS ZN=n_1671 A=n_1760
Xi_431 AOI21_X1 $PINS ZN=n_1638 A=n_1815 B1=n_1795 B2=n_1812
Xi_430 AOI21_X1 $PINS ZN=n_1637 A=n_1638 B1=n_1819 B2=n_1821
Xi_429 NAND2_X1 $PINS ZN=n_1636 A1=n_1765 A2=n_1637
Xi_428 OAI21_X1 $PINS ZN=Res_imm[47] A=n_1636 B1=hfn_ipo_n6 B2=n_1767
Xi_427 OAI21_X1 $PINS ZN=n_1635 A=n_1765 B1=hfn_ipo_n6 B2=n_1767
Xi_426 XNOR2_X1 $PINS ZN=Res_imm[46] A=n_1637 B=n_1635
Xi_425 NOR2_X1 $PINS ZN=n_1627 A1=n_1800 A2=n_1811
Xi_424 OAI22_X1 $PINS ZN=n_1626 A1=n_1784 A2=n_1796 B1=n_1806 B2=n_1804
Xi_423 XNOR2_X1 $PINS ZN=Res_imm[43] A=n_1627 B=n_1626
Xi_422 XOR2_X1 $PINS Z=Res_imm[42] A=n_1804 B=n_1810
Xi_421 OAI21_X1 $PINS ZN=n_1624 A=n_1719 B1=n_1694 B2=n_1692
Xi_420 AOI21_X1 $PINS ZN=n_1620 A=n_1769 B1=n_1693 B2=n_1686
Xi_419 NOR2_X1 $PINS ZN=n_1618 A1=n_1791 A2=n_1770
Xi_418 XOR2_X1 $PINS Z=Res_imm[39] A=n_1716 B=n_1618
Xi_417 XOR2_X1 $PINS Z=Res_imm[38] A=n_1718 B=n_1620
Xi_416 XOR2_X1 $PINS Z=Res_imm[37] A=n_1720 B=n_1624
Xi_415 NOR2_X1 $PINS ZN=n_1617 A1=n_1761 A2=n_1762
Xi_414 OAI21_X1 $PINS ZN=n_1616 A=n_1755 B1=n_1703 B2=n_1698
Xi_413 AOI21_X2 $PINS ZN=n_1615 A=n_1753 B1=n_1729 B2=n_1755
Xi_412 INV_X1 $PINS ZN=n_1614 A=n_1615
Xi_411 AOI21_X1 $PINS ZN=n_1613 A=n_1758 B1=n_1754 B2=n_1614
Xi_410 AOI21_X1 $PINS ZN=n_1612 A=n_1758 B1=n_1699 B2=n_1696
Xi_409 OAI22_X1 $PINS ZN=n_1611 A1=n_1697 A2=n_1695 B1=n_1671 B2=n_1613
Xi_408 XNOR2_X1 $PINS ZN=Res_imm[36] A=n_1617 B=n_1611
Xi_407 NOR2_X1 $PINS ZN=n_1610 A1=n_1759 A2=n_1671
Xi_406 XOR2_X1 $PINS Z=Res_imm[35] A=n_1613 B=n_1610
Xi_405 XOR2_X2 $PINS Z=Res_imm[34] A=n_1615 B=n_1612
Xi_404 XOR2_X1 $PINS Z=Res_imm[33] A=n_1729 B=n_1616
Xi_403 OAI22_X1 $PINS ZN=n_1609 A1=n_1705 A2=n_1701 B1=n_1777 B2=n_1778
Xi_402 INV_X1 $PINS ZN=n_1607 A=n_977
Xi_401 OAI21_X1 $PINS ZN=n_1606 A=n_1740 B1=n_1738 B2=n_1607
Xi_400 INV_X2 $PINS ZN=n_1605 A=n_1606
Xi_399 OAI21_X1 $PINS ZN=n_1604 A=n_1745 B1=n_1742 B2=n_1605
Xi_398 OAI21_X1 $PINS ZN=n_1603 A=n_761 B1=n_1709 B2=n_1710
Xi_397 OAI22_X1 $PINS ZN=n_1602 A1=n_1709 A2=n_1710 B1=n_1775 B2=n_1604
Xi_396 INV_X1 $PINS ZN=n_1601 A=n_1602
Xi_395 OR2_X1 $PINS ZN=n_1600 A1=n_1757 A2=n_1744
Xi_394 NOR2_X1 $PINS ZN=n_1599 A1=n_1601 A2=n_1600
Xi_393 OAI21_X1 $PINS ZN=n_1598 A=n_1752 B1=n_770 B2=n_1599
Xi_392 XNOR2_X1 $PINS ZN=Res_imm[32] A=n_1609 B=n_1598
Xi_391 OAI21_X1 $PINS ZN=n_1597 A=n_1752 B1=n_1707 B2=n_1704
Xi_390 OAI21_X1 $PINS ZN=n_1596 A=n_1756 B1=n_1744 B2=n_1601
Xi_389 XOR2_X1 $PINS Z=Res_imm[31] A=n_1597 B=n_1596
Xi_388 AOI21_X1 $PINS ZN=n_1595 A=n_1599 B1=n_1601 B2=n_1600
Xi_387 INV_X1 $PINS ZN=Res_imm[30] A=n_1595
Xi_386 XNOR2_X1 $PINS ZN=Res_imm[29] A=n_1604 B=n_1603
Xi_385 AOI21_X1 $PINS ZN=n_1594 A=n_769 B1=n_1713 B2=n_1708
Xi_384 OAI21_X1 $PINS ZN=n_1593 A=n_760 B1=n_921 B2=n_590
Xi_383 AOI21_X2 $PINS ZN=n_1592 A=n_764 B1=n_760 B2=n_1605
Xi_382 OAI21_X1 $PINS ZN=n_1591 A=n_1749 B1=n_1689 B2=n_1592
Xi_381 INV_X1 $PINS ZN=n_1590 A=n_1591
Xi_380 NOR2_X1 $PINS ZN=n_1589 A1=n_1750 A2=n_1689
Xi_379 OAI21_X1 $PINS ZN=n_1588 A=n_1747 B1=n_1751 B2=n_1590
Xi_378 XNOR2_X1 $PINS ZN=Res_imm[28] A=n_1594 B=n_1588
Xi_377 NOR2_X1 $PINS ZN=n_1587 A1=n_1748 A2=n_1751
Xi_376 XOR2_X2 $PINS Z=Res_imm[27] A=n_1590 B=n_1587
Xi_375 XOR2_X2 $PINS Z=Res_imm[26] A=n_1592 B=n_1589
Xi_374 XOR2_X1 $PINS Z=Res_imm[25] A=n_1605 B=n_1593
Xi_373 NOR2_X1 $PINS ZN=n_1582 A1=n_1763 A2=n_1584
Xi_372 XOR2_X2 $PINS Z=Res_imm[23] A=n_973 B=n_1582
Xi_371 NOR2_X1 $PINS ZN=n_1581 A1=n_1655 A2=n_1630
Xi_370 NOR2_X1 $PINS ZN=n_1580 A1=n_1655 A2=n_1631
Xi_369 NOR2_X1 $PINS ZN=n_1579 A1=n_1655 A2=n_1632
Xi_368 NOR2_X1 $PINS ZN=n_1578 A1=n_1655 A2=n_1633
Xi_367 NOR2_X1 $PINS ZN=n_1577 A1=n_1655 A2=n_1634
Xi_366 NOR2_X1 $PINS ZN=n_1576 A1=n_1655 A2=n_1639
Xi_365 NOR2_X1 $PINS ZN=n_1575 A1=n_1655 A2=n_1640
Xi_364 NOR2_X1 $PINS ZN=n_1574 A1=n_1655 A2=n_1641
Xi_1067 NOR2_X1 $PINS ZN=n_1573 A1=n_1655 A2=n_1642
Xi_1066 NOR2_X1 $PINS ZN=n_1572 A1=n_1655 A2=n_1643
Xi_363 NOR2_X1 $PINS ZN=n_1571 A1=n_1655 A2=n_1644
Xi_1064 NOR2_X1 $PINS ZN=n_1570 A1=n_1655 A2=n_1645
Xi_362 NOR2_X1 $PINS ZN=n_756 A1=n_1655 A2=n_1646
Xi_361 NOR2_X1 $PINS ZN=n_1560 A1=n_1656 A2=n_1629
Xi_360 NOR2_X1 $PINS ZN=n_1559 A1=n_1656 A2=n_1630
Xi_359 NOR2_X1 $PINS ZN=n_1558 A1=n_1656 A2=n_1631
Xi_358 NOR2_X1 $PINS ZN=n_1557 A1=n_1656 A2=n_1632
Xi_357 NOR2_X1 $PINS ZN=n_1556 A1=n_1656 A2=n_1633
Xi_356 NOR2_X1 $PINS ZN=n_1555 A1=n_1656 A2=n_1634
Xi_355 NOR2_X1 $PINS ZN=n_1554 A1=n_1656 A2=n_1639
Xi_354 NOR2_X1 $PINS ZN=n_1553 A1=n_1656 A2=n_1640
Xi_1046 NOR2_X1 $PINS ZN=n_1552 A1=n_1656 A2=n_1641
Xi_353 NOR2_X1 $PINS ZN=n_1551 A1=n_1656 A2=n_1642
Xi_352 NOR2_X1 $PINS ZN=n_1550 A1=n_1656 A2=n_1643
Xi_1043 NOR2_X1 $PINS ZN=n_1549 A1=n_1656 A2=n_1644
Xi_351 NOR2_X1 $PINS ZN=n_1538 A1=n_1657 A2=n_1625
Xi_350 NOR2_X1 $PINS ZN=n_1537 A1=n_1657 A2=n_1628
Xi_349 NOR2_X1 $PINS ZN=n_739 A1=n_1657 A2=n_1629
Xi_348 NOR2_X1 $PINS ZN=n_1535 A1=n_1657 A2=n_1630
Xi_347 NOR2_X1 $PINS ZN=n_1534 A1=n_1657 A2=n_1631
Xi_346 NOR2_X1 $PINS ZN=n_1533 A1=n_1657 A2=n_1632
Xi_345 NOR2_X1 $PINS ZN=n_1532 A1=n_1657 A2=n_1633
Xi_344 NOR2_X1 $PINS ZN=n_1531 A1=n_1657 A2=n_1634
Xi_343 NOR2_X1 $PINS ZN=n_1530 A1=n_1657 A2=n_1639
Xi_1023 NOR2_X1 $PINS ZN=n_1529 A1=n_1657 A2=n_1640
Xi_342 NOR2_X1 $PINS ZN=n_1528 A1=n_1657 A2=n_1641
Xi_1021 NOR2_X1 $PINS ZN=n_1527 A1=n_1657 A2=n_1642
Xi_1020 NOR2_X1 $PINS ZN=n_1526 A1=n_1657 A2=n_1643
Xi_341 NOR2_X1 $PINS ZN=n_1515 A1=n_1657 A2=n_1654
Xi_340 NOR2_X1 $PINS ZN=n_1514 A1=n_1658 A2=n_1625
Xi_339 NOR2_X1 $PINS ZN=n_738 A1=n_1658 A2=n_1628
Xi_338 NOR2_X1 $PINS ZN=n_1512 A1=n_1658 A2=n_1629
Xi_337 NOR2_X1 $PINS ZN=n_1511 A1=n_1658 A2=n_1630
Xi_336 NOR2_X1 $PINS ZN=n_1510 A1=n_1658 A2=n_1631
Xi_335 NOR2_X1 $PINS ZN=n_1509 A1=n_1658 A2=n_1632
Xi_334 NOR2_X1 $PINS ZN=n_1508 A1=n_1658 A2=n_1633
Xi_333 NOR2_X1 $PINS ZN=n_1507 A1=n_1658 A2=n_1634
Xi_1000 NOR2_X1 $PINS ZN=n_1506 A1=n_1658 A2=n_1639
Xi_332 NOR2_X1 $PINS ZN=n_1505 A1=n_1658 A2=n_1640
Xi_998 NOR2_X1 $PINS ZN=n_1504 A1=n_1658 A2=n_1641
Xi_997 NOR2_X1 $PINS ZN=n_1503 A1=n_1658 A2=n_1642
Xi_331 NOR2_X1 $PINS ZN=n_1492 A1=n_1658 A2=n_1653
Xi_330 NOR2_X1 $PINS ZN=n_1491 A1=n_1658 A2=n_1654
Xi_329 NOR2_X1 $PINS ZN=n_737 A1=n_1659 A2=n_1625
Xi_328 NOR2_X1 $PINS ZN=n_1489 A1=n_1659 A2=n_1628
Xi_327 NOR2_X1 $PINS ZN=n_1488 A1=n_1659 A2=n_1629
Xi_326 NOR2_X1 $PINS ZN=n_1487 A1=n_1659 A2=n_1630
Xi_325 NOR2_X1 $PINS ZN=n_1486 A1=n_1659 A2=n_1631
Xi_324 NOR2_X1 $PINS ZN=n_1485 A1=n_1659 A2=n_1632
Xi_323 NOR2_X1 $PINS ZN=n_1484 A1=n_1659 A2=n_1633
Xi_977 NOR2_X1 $PINS ZN=n_1483 A1=n_1659 A2=n_1634
Xi_976 NOR2_X1 $PINS ZN=n_1482 A1=n_1659 A2=n_1639
Xi_975 NOR2_X1 $PINS ZN=n_1481 A1=n_1659 A2=n_1640
Xi_974 NOR2_X1 $PINS ZN=n_1480 A1=n_1659 A2=n_1641
Xi_322 NOR2_X1 $PINS ZN=n_1469 A1=n_1659 A2=n_1652
Xi_321 NOR2_X1 $PINS ZN=n_1468 A1=n_1659 A2=n_1653
Xi_320 NOR2_X1 $PINS ZN=n_1467 A1=n_1659 A2=n_1654
Xi_319 NOR2_X1 $PINS ZN=n_1466 A1=n_1660 A2=n_1625
Xi_318 NOR2_X1 $PINS ZN=n_1465 A1=n_1660 A2=n_1628
Xi_317 NOR2_X1 $PINS ZN=n_1464 A1=n_1660 A2=n_1629
Xi_316 NOR2_X1 $PINS ZN=n_1463 A1=n_1660 A2=n_1630
Xi_315 NOR2_X1 $PINS ZN=n_1462 A1=n_1660 A2=n_1631
Xi_314 NOR2_X1 $PINS ZN=n_1461 A1=n_1660 A2=n_1632
Xi_954 NOR2_X1 $PINS ZN=n_1460 A1=n_1660 A2=n_1633
Xi_953 NOR2_X1 $PINS ZN=n_1459 A1=n_1660 A2=n_1634
Xi_952 NOR2_X1 $PINS ZN=n_1458 A1=n_1660 A2=n_1639
Xi_951 NOR2_X1 $PINS ZN=n_1457 A1=n_1660 A2=n_1640
Xi_313 NOR2_X1 $PINS ZN=n_1446 A1=n_1660 A2=n_1651
Xi_312 NOR2_X1 $PINS ZN=n_1445 A1=n_1660 A2=n_1652
Xi_311 NOR2_X1 $PINS ZN=n_1444 A1=n_1660 A2=n_1653
Xi_310 NOR2_X1 $PINS ZN=n_1443 A1=n_1660 A2=n_1654
Xi_309 NOR2_X1 $PINS ZN=n_1442 A1=n_1661 A2=n_1625
Xi_308 NOR2_X1 $PINS ZN=n_1441 A1=n_1661 A2=n_1628
Xi_307 NOR2_X1 $PINS ZN=n_1440 A1=n_1661 A2=n_1629
Xi_306 NOR2_X1 $PINS ZN=n_1439 A1=n_1661 A2=n_1630
Xi_305 NOR2_X1 $PINS ZN=n_1438 A1=n_1661 A2=n_1631
Xi_931 NOR2_X1 $PINS ZN=n_1437 A1=n_1661 A2=n_1632
Xi_930 NOR2_X1 $PINS ZN=n_1436 A1=n_1661 A2=n_1633
Xi_929 NOR2_X1 $PINS ZN=n_1435 A1=n_1661 A2=n_1634
Xi_928 NOR2_X1 $PINS ZN=n_1434 A1=n_1661 A2=n_1639
Xi_304 NOR2_X1 $PINS ZN=n_1423 A1=n_1661 A2=n_1650
Xi_303 NOR2_X1 $PINS ZN=n_1422 A1=n_1661 A2=n_1651
Xi_302 NOR2_X1 $PINS ZN=n_1421 A1=n_1661 A2=n_1652
Xi_301 NOR2_X1 $PINS ZN=n_1420 A1=n_1661 A2=n_1653
Xi_300 NOR2_X1 $PINS ZN=n_1419 A1=n_1661 A2=n_1654
Xi_299 NOR2_X1 $PINS ZN=n_1418 A1=n_1662 A2=n_1625
Xi_298 NOR2_X1 $PINS ZN=n_1417 A1=n_1662 A2=n_1628
Xi_297 NOR2_X1 $PINS ZN=n_1416 A1=n_1662 A2=n_1629
Xi_296 NOR2_X1 $PINS ZN=n_1415 A1=n_1662 A2=n_1630
Xi_908 NOR2_X1 $PINS ZN=n_1414 A1=n_1662 A2=n_1631
Xi_907 NOR2_X1 $PINS ZN=n_1413 A1=n_1662 A2=n_1632
Xi_906 NOR2_X1 $PINS ZN=n_1412 A1=n_1662 A2=n_1633
Xi_905 NOR2_X1 $PINS ZN=n_1411 A1=n_1662 A2=n_1634
Xi_295 NOR2_X1 $PINS ZN=n_1400 A1=n_1662 A2=n_1649
Xi_294 NOR2_X1 $PINS ZN=n_1399 A1=n_1662 A2=n_1650
Xi_293 NOR2_X1 $PINS ZN=n_1398 A1=n_1662 A2=n_1651
Xi_292 NOR2_X1 $PINS ZN=n_1397 A1=n_1662 A2=n_1652
Xi_291 NOR2_X1 $PINS ZN=n_1396 A1=n_1662 A2=n_1653
Xi_290 NOR2_X1 $PINS ZN=n_1395 A1=n_1662 A2=n_1654
Xi_289 NOR2_X1 $PINS ZN=n_1394 A1=n_1663 A2=n_1625
Xi_288 NOR2_X1 $PINS ZN=n_1393 A1=n_1663 A2=n_1628
Xi_287 NOR2_X1 $PINS ZN=n_1392 A1=n_1663 A2=n_1629
Xi_885 NOR2_X1 $PINS ZN=n_1391 A1=n_1663 A2=n_1630
Xi_884 NOR2_X1 $PINS ZN=n_1390 A1=n_1663 A2=n_1631
Xi_883 NOR2_X1 $PINS ZN=n_1389 A1=n_1663 A2=n_1632
Xi_882 NOR2_X1 $PINS ZN=n_1388 A1=n_1663 A2=n_1633
Xi_286 NOR2_X1 $PINS ZN=n_1377 A1=n_1663 A2=n_1648
Xi_285 NOR2_X1 $PINS ZN=n_1376 A1=n_1663 A2=n_1649
Xi_284 NOR2_X1 $PINS ZN=n_1375 A1=n_1663 A2=n_1650
Xi_283 NOR2_X1 $PINS ZN=n_1374 A1=n_1663 A2=n_1651
Xi_282 NOR2_X1 $PINS ZN=n_1373 A1=n_1663 A2=n_1652
Xi_281 NOR2_X1 $PINS ZN=n_1372 A1=n_1663 A2=n_1653
Xi_280 NOR2_X1 $PINS ZN=n_1371 A1=n_1663 A2=n_1654
Xi_279 NOR2_X1 $PINS ZN=n_1370 A1=n_1664 A2=n_1625
Xi_278 NOR2_X1 $PINS ZN=n_1369 A1=n_1664 A2=n_1628
Xi_862 NOR2_X1 $PINS ZN=n_1368 A1=n_1664 A2=n_1629
Xi_861 NOR2_X1 $PINS ZN=n_1367 A1=n_1664 A2=n_1630
Xi_860 NOR2_X1 $PINS ZN=n_1366 A1=n_1664 A2=n_1631
Xi_859 NOR2_X1 $PINS ZN=n_1365 A1=n_1664 A2=n_1632
Xi_277 NOR2_X1 $PINS ZN=n_1354 A1=n_1664 A2=n_1647
Xi_276 NOR2_X1 $PINS ZN=n_1353 A1=n_1664 A2=n_1648
Xi_275 NOR2_X1 $PINS ZN=n_1352 A1=n_1664 A2=n_1649
Xi_274 NOR2_X1 $PINS ZN=n_1351 A1=n_1664 A2=n_1650
Xi_273 NOR2_X1 $PINS ZN=n_1350 A1=n_1664 A2=n_1651
Xi_272 NOR2_X1 $PINS ZN=n_1349 A1=n_1664 A2=n_1652
Xi_271 NOR2_X1 $PINS ZN=n_736 A1=n_1664 A2=n_1653
Xi_270 NOR2_X1 $PINS ZN=n_1346 A1=n_1665 A2=n_1625
Xi_839 NOR2_X1 $PINS ZN=n_1345 A1=n_1665 A2=n_1628
Xi_838 NOR2_X1 $PINS ZN=n_1344 A1=n_1665 A2=n_1629
Xi_837 NOR2_X1 $PINS ZN=n_1343 A1=n_1665 A2=n_1630
Xi_836 NOR2_X1 $PINS ZN=n_1342 A1=n_1665 A2=n_1631
Xi_269 NOR2_X1 $PINS ZN=n_1331 A1=n_1665 A2=n_1646
Xi_268 NOR2_X1 $PINS ZN=n_1330 A1=n_1665 A2=n_1647
Xi_267 NOR2_X1 $PINS ZN=n_1329 A1=n_1665 A2=n_1648
Xi_266 NOR2_X1 $PINS ZN=n_1328 A1=n_1665 A2=n_1649
Xi_265 NOR2_X1 $PINS ZN=n_1327 A1=n_1665 A2=n_1650
Xi_264 NOR2_X1 $PINS ZN=n_1326 A1=n_1665 A2=n_1651
Xi_263 NOR2_X1 $PINS ZN=n_734 A1=n_1665 A2=n_1652
Xi_816 NOR2_X1 $PINS ZN=n_1322 A1=n_1666 A2=n_1625
Xi_815 NOR2_X1 $PINS ZN=n_1321 A1=n_1666 A2=n_1628
Xi_262 NOR2_X1 $PINS ZN=n_1320 A1=n_1666 A2=n_1629
Xi_813 NOR2_X1 $PINS ZN=n_1319 A1=n_1666 A2=n_1630
Xi_261 NOR2_X1 $PINS ZN=n_1308 A1=n_1666 A2=n_1645
Xi_260 NOR2_X1 $PINS ZN=n_1307 A1=n_1666 A2=n_1646
Xi_259 NOR2_X1 $PINS ZN=n_1306 A1=n_1666 A2=n_1647
Xi_258 NOR2_X1 $PINS ZN=n_1305 A1=n_1666 A2=n_1648
Xi_257 NOR2_X1 $PINS ZN=n_1304 A1=n_1666 A2=n_1649
Xi_256 NOR2_X1 $PINS ZN=n_1303 A1=n_1666 A2=n_1650
Xi_255 NOR2_X1 $PINS ZN=n_731 A1=n_1666 A2=n_1651
Xi_792 NOR2_X1 $PINS ZN=n_1298 A1=n_1667 A2=n_1625
Xi_254 NOR2_X1 $PINS ZN=n_1297 A1=n_1667 A2=n_1628
Xi_790 NOR2_X1 $PINS ZN=n_1296 A1=n_1667 A2=n_1629
Xi_253 NOR2_X1 $PINS ZN=n_1285 A1=n_1667 A2=n_1644
Xi_252 NOR2_X1 $PINS ZN=n_1284 A1=n_1667 A2=n_1645
Xi_251 NOR2_X1 $PINS ZN=n_1283 A1=n_1667 A2=n_1646
Xi_250 NOR2_X1 $PINS ZN=n_1282 A1=n_1667 A2=n_1647
Xi_249 NOR2_X1 $PINS ZN=n_1281 A1=n_1667 A2=n_1648
Xi_248 NOR2_X1 $PINS ZN=n_1280 A1=n_1667 A2=n_1649
Xi_247 NOR2_X1 $PINS ZN=n_729 A1=n_1667 A2=n_1650
Xi_246 NOR2_X1 $PINS ZN=n_1274 A1=n_1668 A2=n_1625
Xi_767 NOR2_X1 $PINS ZN=n_1273 A1=n_1668 A2=n_1628
Xi_245 NOR2_X1 $PINS ZN=n_705 A1=n_1668 A2=n_1629
Xi_244 NOR2_X1 $PINS ZN=n_1262 A1=n_1668 A2=n_1643
Xi_243 NOR2_X1 $PINS ZN=n_1261 A1=n_1668 A2=n_1644
Xi_242 NOR2_X1 $PINS ZN=n_1260 A1=n_1668 A2=n_1645
Xi_241 NOR2_X1 $PINS ZN=n_1259 A1=n_1668 A2=n_1646
Xi_240 NOR2_X1 $PINS ZN=n_1258 A1=n_1668 A2=n_1647
Xi_239 NOR2_X1 $PINS ZN=n_1257 A1=n_1668 A2=n_1648
Xi_238 NOR2_X1 $PINS ZN=n_704 A1=n_1668 A2=n_1649
Xi_744 NOR2_X1 $PINS ZN=n_1250 A1=n_1669 A2=n_1625
Xi_237 NOR2_X1 $PINS ZN=n_703 A1=n_1669 A2=n_1628
Xi_236 NOR2_X1 $PINS ZN=n_1239 A1=n_1669 A2=n_1642
Xi_235 NOR2_X1 $PINS ZN=n_1238 A1=n_1669 A2=n_1643
Xi_234 NOR2_X1 $PINS ZN=n_1237 A1=n_1669 A2=n_1644
Xi_233 NOR2_X1 $PINS ZN=n_1236 A1=n_1669 A2=n_1645
Xi_232 NOR2_X1 $PINS ZN=n_1235 A1=n_1669 A2=n_1646
Xi_231 NOR2_X1 $PINS ZN=n_1234 A1=n_1669 A2=n_1647
Xi_230 NOR2_X1 $PINS ZN=n_702 A1=n_1669 A2=n_1648
Xi_229 NOR2_X1 $PINS ZN=n_700 A1=n_1670 A2=n_1625
Xi_228 NOR2_X1 $PINS ZN=n_1216 A1=n_1670 A2=n_1641
Xi_227 NOR2_X1 $PINS ZN=n_1215 A1=n_1670 A2=n_1642
Xi_226 NOR2_X1 $PINS ZN=n_1214 A1=n_1670 A2=n_1643
Xi_225 NOR2_X1 $PINS ZN=n_1213 A1=n_1670 A2=n_1644
Xi_224 NOR2_X1 $PINS ZN=n_1212 A1=n_1670 A2=n_1645
Xi_223 NOR2_X1 $PINS ZN=n_1211 A1=n_1670 A2=n_1646
Xi_222 NOR2_X1 $PINS ZN=n_669 A1=n_1670 A2=n_1647
Xi_221 NOR2_X1 $PINS ZN=n_1193 A1=n_1672 A2=n_1640
Xi_220 NOR2_X1 $PINS ZN=n_1192 A1=n_1672 A2=n_1641
Xi_219 NOR2_X1 $PINS ZN=n_1191 A1=n_1672 A2=n_1642
Xi_218 NOR2_X1 $PINS ZN=n_1190 A1=n_1672 A2=n_1643
Xi_217 NOR2_X1 $PINS ZN=n_1189 A1=n_1672 A2=n_1644
Xi_216 NOR2_X1 $PINS ZN=n_1188 A1=n_1672 A2=n_1645
Xi_215 NOR2_X1 $PINS ZN=n_668 A1=n_1672 A2=n_1646
Xi_214 NOR2_X1 $PINS ZN=n_1170 A1=n_1673 A2=n_1639
Xi_213 NOR2_X1 $PINS ZN=n_1169 A1=n_1673 A2=n_1640
Xi_212 NOR2_X1 $PINS ZN=n_1168 A1=n_1673 A2=n_1641
Xi_211 NOR2_X1 $PINS ZN=n_1167 A1=n_1673 A2=n_1642
Xi_210 NOR2_X1 $PINS ZN=n_1166 A1=n_1673 A2=n_1643
Xi_209 NOR2_X1 $PINS ZN=n_1165 A1=n_1673 A2=n_1644
Xi_208 NOR2_X1 $PINS ZN=n_667 A1=n_1673 A2=n_1645
Xi_207 NOR2_X1 $PINS ZN=n_1147 A1=n_1674 A2=n_1634
Xi_206 NOR2_X1 $PINS ZN=n_1146 A1=n_1674 A2=n_1639
Xi_205 NOR2_X1 $PINS ZN=n_1145 A1=n_1674 A2=n_1640
Xi_204 NOR2_X1 $PINS ZN=n_1144 A1=n_1674 A2=n_1641
Xi_203 NOR2_X1 $PINS ZN=n_1143 A1=n_1674 A2=n_1642
Xi_202 NOR2_X1 $PINS ZN=n_1142 A1=n_1674 A2=n_1643
Xi_201 NOR2_X1 $PINS ZN=n_1141 A1=n_1674 A2=n_1644
Xi_200 NOR2_X1 $PINS ZN=n_1124 A1=n_1675 A2=n_1633
Xi_199 NOR2_X1 $PINS ZN=n_1123 A1=n_1675 A2=n_1634
Xi_198 NOR2_X1 $PINS ZN=n_1122 A1=n_1675 A2=n_1639
Xi_197 NOR2_X1 $PINS ZN=n_1121 A1=n_1675 A2=n_1640
Xi_196 NOR2_X1 $PINS ZN=n_1120 A1=n_1675 A2=n_1641
Xi_195 NOR2_X1 $PINS ZN=n_1119 A1=n_1675 A2=n_1642
Xi_194 NOR2_X1 $PINS ZN=n_1118 A1=n_1675 A2=n_1643
Xi_193 NOR2_X1 $PINS ZN=n_1101 A1=n_1676 A2=n_1632
Xi_192 NOR2_X1 $PINS ZN=n_1100 A1=n_1676 A2=n_1633
Xi_191 NOR2_X1 $PINS ZN=n_1099 A1=n_1676 A2=n_1634
Xi_190 NOR2_X1 $PINS ZN=n_1098 A1=n_1676 A2=n_1639
Xi_189 NOR2_X1 $PINS ZN=n_1097 A1=n_1676 A2=n_1640
Xi_188 NOR2_X1 $PINS ZN=n_1096 A1=n_1676 A2=n_1641
Xi_187 NOR2_X1 $PINS ZN=n_1095 A1=n_1676 A2=n_1642
Xi_186 NOR2_X1 $PINS ZN=n_1078 A1=n_1677 A2=n_1631
Xi_185 NOR2_X1 $PINS ZN=n_1077 A1=n_1677 A2=n_1632
Xi_184 NOR2_X1 $PINS ZN=n_1076 A1=n_1677 A2=n_1633
Xi_183 NOR2_X1 $PINS ZN=n_1075 A1=n_1677 A2=n_1634
Xi_182 NOR2_X1 $PINS ZN=n_1074 A1=n_1677 A2=n_1639
Xi_181 NOR2_X1 $PINS ZN=n_1073 A1=n_1677 A2=n_1640
Xi_180 NOR2_X1 $PINS ZN=n_1072 A1=n_1677 A2=n_1641
Xi_179 NOR2_X1 $PINS ZN=n_1055 A1=n_1678 A2=n_1630
Xi_178 NOR2_X1 $PINS ZN=n_1054 A1=n_1678 A2=n_1631
Xi_177 NOR2_X1 $PINS ZN=n_1053 A1=n_1678 A2=n_1632
Xi_176 NOR2_X1 $PINS ZN=n_1052 A1=n_1678 A2=n_1633
Xi_175 NOR2_X1 $PINS ZN=n_1051 A1=n_1678 A2=n_1634
Xi_174 NOR2_X1 $PINS ZN=n_1050 A1=n_1678 A2=n_1639
Xi_173 NOR2_X1 $PINS ZN=n_1049 A1=n_1678 A2=n_1640
Xi_172 NOR2_X1 $PINS ZN=n_1032 A1=n_1654 A2=n_1629
Xi_171 NOR2_X1 $PINS ZN=n_1031 A1=n_1654 A2=n_1630
Xi_170 NOR2_X1 $PINS ZN=n_1030 A1=n_1654 A2=n_1631
Xi_169 NOR2_X1 $PINS ZN=n_1029 A1=n_1654 A2=n_1632
Xi_168 NOR2_X1 $PINS ZN=n_1028 A1=n_1654 A2=n_1633
Xi_167 NOR2_X1 $PINS ZN=n_1027 A1=n_1654 A2=n_1634
Xi_166 NOR2_X1 $PINS ZN=n_1026 A1=n_1654 A2=n_1639
Xi_165 FA_X1 $PINS CO=n_666 S=n_664 A=n_782 B=n_759 CI=n_757
Xi_164 FA_X1 $PINS CO=n_631 S=n_629 A=n_772 B=n_755 CI=n_784
Xi_163 FA_X1 $PINS CO=n_549 S=n_548 A=n_1690 B=n_1691 CI=n_774
Xi_162 FA_X1 $PINS CO=n_547 S=n_545 A=n_753 B=n_751 CI=n_1688
Xi_161 FA_X1 $PINS CO=n_543 S=n_784 A=n_745 B=n_743 CI=n_741
Xi_160 FA_X1 $PINS CO=n_541 S=n_782 A=n_1371 B=n_749 CI=n_747
Xi_159 FA_X1 $PINS CO=n_539 S=n_774 A=n_1095 B=n_1118 CI=n_1141
Xi_158 FA_X1 $PINS CO=n_537 S=n_772 A=n_1026 B=n_1049 CI=n_1072
Xi_157 FA_X1 $PINS CO=n_535 S=n_533 A=n_733 B=n_1700 CI=n_735
Xi_156 FA_X1 $PINS CO=n_531 S=n_529 A=n_725 B=n_723 CI=n_727
Xi_155 FA_X1 $PINS CO=n_527 S=n_525 A=n_740 B=n_754 CI=n_752
Xi_154 FA_X1 $PINS CO=n_759 S=n_523 A=n_746 B=n_744 CI=n_742
Xi_153 FA_X1 $PINS CO=n_757 S=n_521 A=n_719 B=n_750 CI=n_748
Xi_152 FA_X1 $PINS CO=n_755 S=n_754 A=n_709 B=n_707 CI=n_721
Xi_151 FA_X1 $PINS CO=n_753 S=n_752 A=n_715 B=n_713 CI=n_711
Xi_150 FA_X1 $PINS CO=n_751 S=n_750 A=n_1372 B=n_1395 CI=n_717
Xi_149 FA_X1 $PINS CO=n_749 S=n_748 A=n_1303 B=n_1326 CI=n_1349
Xi_148 FA_X1 $PINS CO=n_747 S=n_746 A=n_1234 B=n_1257 CI=n_1280
Xi_147 FA_X1 $PINS CO=n_745 S=n_744 A=n_1165 B=n_1188 CI=n_1211
Xi_146 FA_X1 $PINS CO=n_743 S=n_742 A=n_1096 B=n_1119 CI=n_1142
Xi_145 FA_X1 $PINS CO=n_741 S=n_740 A=n_1027 B=n_1050 CI=n_1073
Xi_144 FA_X1 $PINS CO=n_519 S=n_517 A=n_699 B=n_732 CI=n_701
Xi_143 FA_X1 $PINS CO=n_735 S=n_515 A=n_728 B=n_697 CI=n_730
Xi_142 FA_X1 $PINS CO=n_733 S=n_732 A=n_693 B=n_726 CI=n_724
Xi_141 FA_X1 $PINS CO=n_513 S=n_730 A=n_689 B=n_722 CI=n_695
Xi_140 FA_X1 $PINS CO=n_511 S=n_728 A=n_720 B=n_718 CI=n_691
Xi_139 FA_X1 $PINS CO=n_727 S=n_726 A=n_708 B=n_706 CI=n_687
Xi_138 FA_X1 $PINS CO=n_725 S=n_724 A=n_714 B=n_712 CI=n_710
Xi_137 FA_X1 $PINS CO=n_723 S=n_722 A=n_685 B=n_683 CI=n_716
Xi_136 FA_X1 $PINS CO=n_721 S=n_720 A=n_675 B=n_673 CI=n_671
Xi_135 FA_X1 $PINS CO=n_719 S=n_718 A=n_681 B=n_679 CI=n_677
Xi_134 FA_X1 $PINS CO=n_717 S=n_716 A=n_1373 B=n_1396 CI=n_1419
Xi_133 FA_X1 $PINS CO=n_715 S=n_714 A=n_1304 B=n_1327 CI=n_1350
Xi_132 FA_X1 $PINS CO=n_713 S=n_712 A=n_1235 B=n_1258 CI=n_1281
Xi_131 FA_X1 $PINS CO=n_711 S=n_710 A=n_1166 B=n_1189 CI=n_1212
Xi_130 FA_X1 $PINS CO=n_709 S=n_708 A=n_1097 B=n_1120 CI=n_1143
Xi_129 FA_X1 $PINS CO=n_707 S=n_706 A=n_1028 B=n_1051 CI=n_1074
Xi_128 FA_X1 $PINS CO=n_509 S=n_507 A=n_663 B=n_698 CI=n_665
Xi_127 FA_X1 $PINS CO=n_701 S=n_505 A=n_692 B=n_661 CI=n_696
Xi_126 FA_X1 $PINS CO=n_699 S=n_698 A=n_688 B=n_659 CI=n_694
Xi_125 FA_X1 $PINS CO=n_697 S=n_696 A=n_686 B=n_657 CI=n_690
Xi_124 FA_X1 $PINS CO=n_695 S=n_694 A=n_655 B=n_653 CI=n_651
Xi_123 FA_X1 $PINS CO=n_693 S=n_692 A=n_670 B=n_684 CI=n_682
Xi_122 FA_X1 $PINS CO=n_691 S=n_690 A=n_676 B=n_674 CI=n_672
Xi_121 FA_X1 $PINS CO=n_689 S=n_688 A=n_645 B=n_680 CI=n_678
Xi_120 FA_X1 $PINS CO=n_687 S=n_686 A=n_633 B=n_649 CI=n_647
Xi_119 FA_X1 $PINS CO=n_685 S=n_684 A=n_639 B=n_637 CI=n_635
Xi_118 FA_X1 $PINS CO=n_683 S=n_682 A=n_1443 B=n_643 CI=n_641
Xi_117 FA_X1 $PINS CO=n_681 S=n_680 A=n_1374 B=n_1397 CI=n_1420
Xi_116 FA_X1 $PINS CO=n_679 S=n_678 A=n_1305 B=n_1328 CI=n_1351
Xi_115 FA_X1 $PINS CO=n_677 S=n_676 A=n_1236 B=n_1259 CI=n_1282
Xi_114 FA_X1 $PINS CO=n_675 S=n_674 A=n_1167 B=n_1190 CI=n_1213
Xi_113 FA_X1 $PINS CO=n_673 S=n_672 A=n_1098 B=n_1121 CI=n_1144
Xi_112 FA_X1 $PINS CO=n_671 S=n_670 A=n_1029 B=n_1052 CI=n_1075
Xi_111 FA_X1 $PINS CO=n_504 S=n_461 A=n_625 B=n_662 CI=n_627
Xi_110 FA_X1 $PINS CO=n_665 S=n_169 A=n_656 B=n_623 CI=n_660
Xi_109 FA_X1 $PINS CO=n_663 S=n_662 A=n_652 B=n_621 CI=n_658
Xi_108 FA_X1 $PINS CO=n_661 S=n_660 A=n_619 B=n_617 CI=n_654
Xi_107 FA_X1 $PINS CO=n_659 S=n_658 A=n_615 B=n_613 CI=n_650
Xi_106 FA_X1 $PINS CO=n_657 S=n_656 A=n_611 B=n_648 CI=n_646
Xi_105 FA_X1 $PINS CO=n_655 S=n_654 A=n_636 B=n_634 CI=n_632
Xi_104 FA_X1 $PINS CO=n_653 S=n_652 A=n_642 B=n_640 CI=n_638
Xi_103 FA_X1 $PINS CO=n_651 S=n_650 A=n_609 B=n_607 CI=n_644
Xi_102 FA_X1 $PINS CO=n_649 S=n_648 A=n_597 B=n_595 CI=n_593
Xi_101 FA_X1 $PINS CO=n_647 S=n_646 A=n_603 B=n_601 CI=n_599
Xi_100 FA_X1 $PINS CO=n_645 S=n_644 A=n_1444 B=n_1467 CI=n_605
Xi_99 FA_X1 $PINS CO=n_643 S=n_642 A=n_1375 B=n_1398 CI=n_1421
Xi_98 FA_X1 $PINS CO=n_641 S=n_640 A=n_1306 B=n_1329 CI=n_1352
Xi_97 FA_X1 $PINS CO=n_639 S=n_638 A=n_1237 B=n_1260 CI=n_1283
Xi_96 FA_X1 $PINS CO=n_637 S=n_636 A=n_1168 B=n_1191 CI=n_1214
Xi_95 FA_X1 $PINS CO=n_635 S=n_634 A=n_1099 B=n_1122 CI=n_1145
Xi_94 FA_X1 $PINS CO=n_633 S=n_632 A=n_1030 B=n_1053 CI=n_1076
Xi_93 FA_X1 $PINS CO=n_168 S=n_630 A=n_626 B=n_589 CI=n_628
Xi_92 FA_X1 $PINS CO=n_167 S=n_628 A=n_622 B=n_624 CI=n_587
Xi_91 FA_X1 $PINS CO=n_627 S=n_626 A=n_583 B=n_620 CI=n_585
Xi_90 FA_X1 $PINS CO=n_625 S=n_624 A=n_616 B=n_581 CI=n_618
Xi_89 FA_X1 $PINS CO=n_623 S=n_622 A=n_577 B=n_614 CI=n_612
Xi_88 FA_X1 $PINS CO=n_621 S=n_620 A=n_571 B=n_610 CI=n_579
Xi_87 FA_X1 $PINS CO=n_619 S=n_618 A=n_606 B=n_575 CI=n_573
Xi_86 FA_X1 $PINS CO=n_617 S=n_616 A=n_592 B=n_569 CI=n_608
Xi_85 FA_X1 $PINS CO=n_615 S=n_614 A=n_598 B=n_596 CI=n_594
Xi_84 FA_X1 $PINS CO=n_613 S=n_612 A=n_604 B=n_602 CI=n_600
Xi_83 FA_X1 $PINS CO=n_611 S=n_610 A=n_551 B=n_567 CI=n_565
Xi_82 FA_X1 $PINS CO=n_609 S=n_608 A=n_557 B=n_555 CI=n_553
Xi_81 FA_X1 $PINS CO=n_607 S=n_606 A=n_563 B=n_561 CI=n_559
Xi_80 FA_X1 $PINS CO=n_605 S=n_604 A=n_1445 B=n_1468 CI=n_1491
Xi_79 FA_X1 $PINS CO=n_603 S=n_602 A=n_1376 B=n_1399 CI=n_1422
Xi_78 FA_X1 $PINS CO=n_601 S=n_600 A=n_1307 B=n_1330 CI=n_1353
Xi_77 FA_X1 $PINS CO=n_599 S=n_598 A=n_1238 B=n_1261 CI=n_1284
Xi_76 FA_X1 $PINS CO=n_597 S=n_596 A=n_1169 B=n_1192 CI=n_1215
Xi_75 FA_X1 $PINS CO=n_595 S=n_594 A=n_1100 B=n_1123 CI=n_1146
Xi_74 FA_X1 $PINS CO=n_593 S=n_592 A=n_1031 B=n_1054 CI=n_1077
Xi_73 FA_X1 $PINS CO=n_591 S=n_590 A=n_586 B=n_588 CI=n_879
Xi_72 FA_X1 $PINS CO=n_589 S=n_588 A=n_582 B=n_584 CI=n_878
Xi_71 FA_X1 $PINS CO=n_587 S=n_586 A=n_580 B=n_855 CI=n_783
Xi_70 FA_X1 $PINS CO=n_585 S=n_584 A=n_578 B=n_576 CI=n_792
Xi_69 FA_X1 $PINS CO=n_583 S=n_582 A=n_574 B=n_572 CI=n_854
Xi_68 FA_X1 $PINS CO=n_581 S=n_580 A=n_787 B=n_570 CI=n_780
Xi_67 FA_X1 $PINS CO=n_579 S=n_578 A=n_564 B=n_791 CI=n_828
Xi_66 FA_X1 $PINS CO=n_577 S=n_576 A=n_829 B=n_568 CI=n_566
Xi_65 FA_X1 $PINS CO=n_575 S=n_574 A=n_554 B=n_552 CI=n_550
Xi_64 FA_X1 $PINS CO=n_573 S=n_572 A=n_560 B=n_558 CI=n_556
Xi_63 FA_X1 $PINS CO=n_571 S=n_570 A=n_778 B=n_793 CI=n_562
Xi_62 FA_X1 $PINS CO=n_569 S=n_568 A=n_785 B=n_786 CI=n_776
Xi_61 FA_X1 $PINS CO=n_567 S=n_566 A=n_788 B=n_789 CI=n_790
Xi_60 FA_X1 $PINS CO=n_565 S=n_564 A=n_1515 B=n_800 CI=n_801
Xi_59 FA_X1 $PINS CO=n_563 S=n_562 A=n_1446 B=n_1469 CI=n_1492
Xi_58 FA_X1 $PINS CO=n_561 S=n_560 A=n_1377 B=n_1400 CI=n_1423
Xi_55 FA_X1 $PINS CO=n_559 S=n_558 A=n_1308 B=n_1331 CI=n_1354
Xi_54 FA_X1 $PINS CO=n_557 S=n_556 A=n_1239 B=n_1262 CI=n_1285
Xi_53 FA_X1 $PINS CO=n_555 S=n_554 A=n_1170 B=n_1193 CI=n_1216
Xi_52 FA_X1 $PINS CO=n_553 S=n_552 A=n_1101 B=n_1124 CI=n_1147
Xi_51 FA_X1 $PINS CO=n_551 S=n_550 A=n_1032 B=n_1055 CI=n_1078
Xi_50 FA_X1 $PINS CO=n_166 S=n_165 A=n_133 B=n_939 CI=n_141
Xi_49 FA_X1 $PINS CO=n_164 S=n_163 A=n_139 B=n_137 CI=n_135
Xi_44 FA_X1 $PINS CO=n_162 S=n_161 A=n_1526 B=n_1549 CI=n_1570
Xi_43 FA_X1 $PINS CO=n_160 S=n_159 A=n_1457 B=n_1480 CI=n_1503
Xi_42 FA_X1 $PINS CO=n_158 S=n_157 A=n_1388 B=n_1411 CI=n_1434
Xi_41 FA_X1 $PINS CO=n_156 S=n_143 A=n_1319 B=n_1342 CI=n_1365
Xi_40 FA_X1 $PINS CO=n_140 S=n_138 A=n_1250 B=n_1273 CI=n_1296
Xi_39 FA_X1 $PINS CO=n_141 S=n_136 A=n_1550 B=n_1571 CI=n_117
Xi_38 FA_X1 $PINS CO=n_139 S=n_134 A=n_1481 B=n_1504 CI=n_1527
Xi_37 FA_X1 $PINS CO=n_137 S=n_132 A=n_1412 B=n_1435 CI=n_1458
Xi_36 FA_X1 $PINS CO=n_135 S=n_119 A=n_1343 B=n_1366 CI=n_1389
Xi_35 FA_X1 $PINS CO=n_133 S=n_118 A=n_1274 B=n_1297 CI=n_1320
Xi_34 FA_X1 $PINS CO=n_116 S=n_115 A=n_1572 B=n_97 CI=n_95
Xi_33 FA_X1 $PINS CO=n_117 S=n_114 A=n_1505 B=n_1528 CI=n_1551
Xi_57 FA_X1 $PINS CO=n_113 S=n_112 A=n_1436 B=n_1459 CI=n_1482
Xi_56 FA_X1 $PINS CO=n_111 S=n_110 A=n_1367 B=n_1390 CI=n_1413
Xi_32 FA_X1 $PINS CO=n_99 S=n_98 A=n_1298 B=n_1321 CI=n_1344
Xi_31 FA_X1 $PINS CO=n_96 S=n_94 A=n_77 B=n_75 CI=n_73
Xi_48 FA_X1 $PINS CO=n_97 S=n_93 A=n_1529 B=n_1552 CI=n_1573
Xi_47 FA_X1 $PINS CO=n_95 S=n_92 A=n_1460 B=n_1483 CI=n_1506
Xi_46 FA_X1 $PINS CO=n_91 S=n_90 A=n_1391 B=n_1414 CI=n_1437
Xi_45 FA_X1 $PINS CO=n_85 S=n_84 A=n_1322 B=n_1345 CI=n_1368
Xi_30 FA_X1 $PINS CO=n_83 S=n_82 A=n_72 B=n_80 CI=n_65
Xi_29 FA_X1 $PINS CO=n_81 S=n_79 A=n_78 B=n_76 CI=n_74
Xi_28 FA_X1 $PINS CO=n_67 S=n_80 A=n_59 B=n_57 CI=n_63
Xi_27 FA_X1 $PINS CO=n_66 S=n_78 A=n_1553 B=n_1574 CI=n_61
Xi_26 FA_X1 $PINS CO=n_77 S=n_76 A=n_1484 B=n_1507 CI=n_1530
Xi_25 FA_X1 $PINS CO=n_75 S=n_74 A=n_1415 B=n_1438 CI=n_1461
Xi_24 FA_X1 $PINS CO=n_73 S=n_72 A=n_1346 B=n_1369 CI=n_1392
Xi_23 FA_X1 $PINS CO=n_64 S=n_51 A=n_56 B=n_49 CI=n_62
Xi_22 FA_X1 $PINS CO=n_65 S=n_50 A=n_43 B=n_60 CI=n_58
Xi_21 FA_X1 $PINS CO=n_63 S=n_62 A=n_1575 B=n_47 CI=n_45
Xi_20 FA_X1 $PINS CO=n_61 S=n_60 A=n_1508 B=n_1531 CI=n_1554
Xi_19 FA_X1 $PINS CO=n_59 S=n_58 A=n_1439 B=n_1462 CI=n_1485
Xi_18 FA_X1 $PINS CO=n_57 S=n_56 A=n_1370 B=n_1393 CI=n_1416
Xi_17 FA_X1 $PINS CO=n_48 S=n_37 A=n_46 B=n_44 CI=n_42
Xi_16 FA_X1 $PINS CO=n_49 S=n_36 A=n_33 B=n_31 CI=n_35
Xi_15 FA_X1 $PINS CO=n_47 S=n_46 A=n_1532 B=n_1555 CI=n_1576
Xi_14 FA_X1 $PINS CO=n_45 S=n_44 A=n_1463 B=n_1486 CI=n_1509
Xi_13 FA_X1 $PINS CO=n_43 S=n_42 A=n_1394 B=n_1417 CI=n_1440
Xi_12 FA_X1 $PINS CO=n_32 S=n_30 A=n_21 B=n_25 CI=n_34
Xi_11 FA_X1 $PINS CO=n_35 S=n_34 A=n_1556 B=n_1577 CI=n_23
Xi_10 FA_X1 $PINS CO=n_33 S=n_24 A=n_1487 B=n_1510 CI=n_1533
Xi_9 FA_X1 $PINS CO=n_31 S=n_22 A=n_1418 B=n_1441 CI=n_1464
Xi_8 FA_X1 $PINS CO=n_25 S=n_20 A=n_1578 B=n_15 CI=n_13
Xi_7 FA_X1 $PINS CO=n_23 S=n_14 A=n_1511 B=n_1534 CI=n_1557
Xi_6 FA_X1 $PINS CO=n_21 S=n_12 A=n_1442 B=n_1465 CI=n_1488
Xi_5 FA_X1 $PINS CO=n_15 S=n_10 A=n_1535 B=n_1558 CI=n_1579
Xi_4 FA_X1 $PINS CO=n_13 S=n_9 A=n_1466 B=n_1489 CI=n_1512
Xi_3 FA_X1 $PINS CO=n_8 S=n_6 A=n_1559 B=n_1580 CI=n_5
Xi_2 HA_X1 $PINS CO=n_5 S=n_4 A=n_1581 B=n_1
Xi_1 FA_X1 $PINS CO=n_3 S=n_2 A=n_1514 B=n_1537 CI=n_1560
Xi_0 HA_X1 $PINS CO=n_1 S=n_0 A=n_1538 B=n_1723
Xhfn_ipo_c6 BUF_X2 $PINS Z=hfn_ipo_n6 A=n_1654
.ENDS

.SUBCKT VM clk_CTS_1_PP_4 clk_CTS_1_PP_5 clk_CTS_1_PP_6 Res[63] Res[62] Res[61]
+ Res[60] Res[59] Res[58] Res[57] Res[56] Res[55] Res[54] Res[53] Res[52]
+ Res[51] Res[50] Res[49] Res[48] Res[47] Res[46] Res[45] Res[44] Res[43]
+ Res[42] Res[41] Res[40] Res[39] Res[38] Res[37] Res[36] Res[35] Res[34]
+ Res[33] Res[32] Res[31] Res[30] Res[29] Res[28] Res[27] Res[26] Res[25]
+ Res[24] Res[23] Res[22] Res[21] Res[20] Res[19] Res[18] Res[17] Res[16]
+ Res[15] Res[14] Res[13] Res[12] Res[11] Res[10] Res[9] Res[8] Res[7] Res[6]
+ Res[5] Res[4] Res[3] Res[2] Res[1] Res[0] OVF A[31] A[30] A[29] A[28] A[27]
+ A[26] A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14]
+ A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] clk reset enable
Xi_0_74 INV_X1 $PINS ZN=n_0_0__1 A=reset
Xi_0_73 NAND2_X2 $PINS ZN=n_119 A1=n_0_0__1 A2=clk_CTS_1_PP_4
Xi_0_72 AND2_X1 $PINS ZN=n_118 A1=hfn_ipo_n6 A2=B[22]
Xi_0_71 AND2_X1 $PINS ZN=n_117 A1=hfn_ipo_n6 A2=B[21]
Xi_0_70 AND2_X1 $PINS ZN=n_116 A1=hfn_ipo_n6 A2=B[20]
Xi_0_69 AND2_X1 $PINS ZN=n_115 A1=hfn_ipo_n6 A2=B[19]
Xi_0_68 AND2_X1 $PINS ZN=n_114 A1=hfn_ipo_n6 A2=B[18]
Xi_0_67 AND2_X1 $PINS ZN=n_113 A1=hfn_ipo_n6 A2=B[17]
Xi_0_66 AND2_X1 $PINS ZN=n_112 A1=hfn_ipo_n6 A2=B[16]
Xi_0_65 AND2_X1 $PINS ZN=n_111 A1=hfn_ipo_n6 A2=B[15]
Xi_0_64 AND2_X1 $PINS ZN=n_110 A1=hfn_ipo_n6 A2=B[14]
Xi_0_63 AND2_X1 $PINS ZN=n_109 A1=hfn_ipo_n6 A2=B[13]
Xi_0_62 AND2_X1 $PINS ZN=n_108 A1=hfn_ipo_n6 A2=B[12]
Xi_0_61 AND2_X1 $PINS ZN=n_107 A1=hfn_ipo_n6 A2=B[11]
Xi_0_60 AND2_X1 $PINS ZN=n_106 A1=hfn_ipo_n6 A2=B[10]
Xi_0_59 AND2_X1 $PINS ZN=n_105 A1=hfn_ipo_n6 A2=B[9]
Xi_0_58 AND2_X1 $PINS ZN=n_104 A1=hfn_ipo_n6 A2=B[8]
Xi_0_57 AND2_X1 $PINS ZN=n_103 A1=hfn_ipo_n6 A2=B[7]
Xi_0_56 AND2_X1 $PINS ZN=n_102 A1=hfn_ipo_n6 A2=B[6]
Xi_0_55 AND2_X1 $PINS ZN=n_101 A1=hfn_ipo_n6 A2=B[5]
Xi_0_54 AND2_X1 $PINS ZN=n_100 A1=hfn_ipo_n6 A2=B[4]
Xi_0_53 AND2_X1 $PINS ZN=n_99 A1=hfn_ipo_n6 A2=B[3]
Xi_0_52 AND2_X1 $PINS ZN=n_98 A1=hfn_ipo_n6 A2=B[2]
Xi_0_51 AND2_X1 $PINS ZN=n_97 A1=hfn_ipo_n6 A2=B[1]
Xi_0_50 AND2_X1 $PINS ZN=n_96 A1=hfn_ipo_n6 A2=B[0]
Xi_0_49 AOI21_X1 $PINS ZN=CTS_n12 A=reset B1=clk_CTS_1_PP_4 B2=enable
XCTS_L4_remove_c14 INV_X4 $PINS ZN=CTS_n11 A=CTS_n12
Xi_0_47 AND2_X1 $PINS ZN=n_94 A1=hfn_ipo_n6 A2=A[22]
Xi_0_46 AND2_X1 $PINS ZN=n_93 A1=hfn_ipo_n6 A2=A[21]
Xi_0_45 AND2_X1 $PINS ZN=n_92 A1=hfn_ipo_n6 A2=A[20]
Xi_0_44 AND2_X1 $PINS ZN=n_91 A1=hfn_ipo_n6 A2=A[19]
Xi_0_43 AND2_X1 $PINS ZN=n_90 A1=hfn_ipo_n6 A2=A[18]
Xi_0_42 AND2_X1 $PINS ZN=n_89 A1=hfn_ipo_n6 A2=A[17]
Xi_0_41 AND2_X1 $PINS ZN=n_88 A1=hfn_ipo_n6 A2=A[16]
Xi_0_40 AND2_X1 $PINS ZN=n_87 A1=hfn_ipo_n6 A2=A[15]
Xi_0_39 AND2_X1 $PINS ZN=n_86 A1=hfn_ipo_n6 A2=A[14]
Xi_0_38 AND2_X1 $PINS ZN=n_85 A1=hfn_ipo_n6 A2=A[13]
Xi_0_37 AND2_X1 $PINS ZN=n_84 A1=hfn_ipo_n6 A2=A[12]
Xi_0_36 AND2_X1 $PINS ZN=n_83 A1=hfn_ipo_n6 A2=A[11]
Xi_0_35 AND2_X1 $PINS ZN=n_82 A1=hfn_ipo_n6 A2=A[10]
Xi_0_34 AND2_X1 $PINS ZN=n_81 A1=hfn_ipo_n6 A2=A[9]
Xi_0_33 AND2_X1 $PINS ZN=n_80 A1=hfn_ipo_n6 A2=A[8]
Xi_0_32 AND2_X1 $PINS ZN=n_79 A1=hfn_ipo_n6 A2=A[7]
Xi_0_31 AND2_X1 $PINS ZN=n_78 A1=hfn_ipo_n6 A2=A[6]
Xi_0_30 AND2_X1 $PINS ZN=n_77 A1=hfn_ipo_n6 A2=A[5]
Xi_0_29 AND2_X1 $PINS ZN=n_76 A1=hfn_ipo_n6 A2=A[4]
Xi_0_28 AND2_X1 $PINS ZN=n_75 A1=hfn_ipo_n6 A2=A[3]
Xi_0_27 AND2_X1 $PINS ZN=n_74 A1=hfn_ipo_n6 A2=A[2]
Xi_0_26 AND2_X1 $PINS ZN=n_73 A1=hfn_ipo_n6 A2=A[1]
Xi_0_25 AND2_X1 $PINS ZN=n_72 A1=hfn_ipo_n6 A2=A[0]
Xi_0_24 AND2_X1 $PINS ZN=n_71 A1=n_0_0__1 A2=Res_imm[47]
Xi_0_23 AND2_X1 $PINS ZN=n_70 A1=n_0_0__1 A2=Res_imm[46]
Xi_0_22 AND2_X1 $PINS ZN=n_69 A1=n_0_0__1 A2=Res_imm[45]
Xi_0_21 AND2_X1 $PINS ZN=n_68 A1=n_0_0__1 A2=Res_imm[44]
Xi_0_20 AND2_X1 $PINS ZN=n_67 A1=n_0_0__1 A2=Res_imm[43]
Xi_0_19 AND2_X1 $PINS ZN=n_66 A1=n_0_0__1 A2=Res_imm[42]
Xi_0_18 AND2_X1 $PINS ZN=n_65 A1=n_0_0__1 A2=Res_imm[41]
Xi_0_17 AND2_X1 $PINS ZN=n_64 A1=n_0_0__1 A2=Res_imm[40]
Xi_0_16 AND2_X1 $PINS ZN=n_63 A1=n_0_0__1 A2=Res_imm[39]
Xi_0_15 AND2_X1 $PINS ZN=n_62 A1=n_0_0__1 A2=Res_imm[38]
Xi_0_14 AND2_X1 $PINS ZN=n_61 A1=n_0_0__1 A2=Res_imm[37]
Xi_0_13 AND2_X1 $PINS ZN=n_60 A1=n_0_0__1 A2=Res_imm[36]
Xi_0_12 AND2_X1 $PINS ZN=n_59 A1=n_0_0__1 A2=Res_imm[35]
Xi_0_11 AND2_X1 $PINS ZN=n_58 A1=n_0_0__1 A2=Res_imm[34]
Xi_0_10 AND2_X1 $PINS ZN=n_57 A1=n_0_0__1 A2=Res_imm[33]
Xi_0_9 AND2_X1 $PINS ZN=n_56 A1=n_0_0__1 A2=Res_imm[32]
Xi_0_8 AND2_X1 $PINS ZN=n_55 A1=n_0_0__1 A2=Res_imm[31]
Xi_0_7 AND2_X1 $PINS ZN=n_54 A1=n_0_0__1 A2=Res_imm[30]
Xi_0_6 AND2_X1 $PINS ZN=n_53 A1=n_0_0__1 A2=Res_imm[29]
Xi_0_5 AND2_X1 $PINS ZN=n_52 A1=n_0_0__1 A2=Res_imm[28]
Xi_0_4 AND2_X1 $PINS ZN=n_51 A1=n_0_0__1 A2=Res_imm[27]
Xi_0_3 AND2_X1 $PINS ZN=n_50 A1=n_0_0__1 A2=Res_imm[26]
Xi_0_2 AND2_X1 $PINS ZN=n_49 A1=n_0_0__1 A2=Res_imm[25]
Xi_0_1 AND2_X1 $PINS ZN=n_48 A1=n_0_0__1 A2=Res_imm[24]
Xi_0_0 AND2_X1 $PINS ZN=n_47 A1=n_0_0__1 A2=Res_imm[23]
XA_in_reg[23] DLH_X1 $PINS Q=n_46 D=hfn_ipo_n6 G=CTS_n11
XA_in_reg[0] DLH_X1 $PINS Q=n_1 D=n_72 G=CTS_n11
XA_in_reg[1] DLH_X1 $PINS Q=n_45 D=n_73 G=CTS_n11
XA_in_reg[2] DLH_X1 $PINS Q=n_44 D=n_74 G=CTS_n11
XA_in_reg[3] DLH_X1 $PINS Q=n_43 D=n_75 G=CTS_n11
XA_in_reg[4] DLH_X1 $PINS Q=n_42 D=n_76 G=CTS_n11
XA_in_reg[5] DLH_X1 $PINS Q=n_41 D=n_77 G=CTS_n11
XA_in_reg[6] DLH_X1 $PINS Q=n_40 D=n_78 G=CTS_n11
XA_in_reg[7] DLH_X1 $PINS Q=n_39 D=n_79 G=CTS_n11
XA_in_reg[8] DLH_X1 $PINS Q=n_38 D=n_80 G=CTS_n11
XA_in_reg[9] DLH_X1 $PINS Q=n_37 D=n_81 G=CTS_n11
XA_in_reg[10] DLH_X1 $PINS Q=n_36 D=n_82 G=CTS_n11
XA_in_reg[11] DLH_X1 $PINS Q=n_35 D=n_83 G=CTS_n11
XA_in_reg[12] DLH_X1 $PINS Q=n_34 D=n_84 G=CTS_n11
XA_in_reg[13] DLH_X1 $PINS Q=n_33 D=n_85 G=CTS_n11
XA_in_reg[14] DLH_X1 $PINS Q=n_32 D=n_86 G=CTS_n11
XA_in_reg[15] DLH_X1 $PINS Q=n_31 D=n_87 G=CTS_n11
XA_in_reg[16] DLH_X1 $PINS Q=n_30 D=n_88 G=CTS_n11
XA_in_reg[17] DLH_X1 $PINS Q=n_29 D=n_89 G=CTS_n11
XA_in_reg[18] DLH_X1 $PINS Q=n_28 D=n_90 G=CTS_n11
XA_in_reg[19] DLH_X1 $PINS Q=n_27 D=n_91 G=CTS_n11
XA_in_reg[20] DLH_X1 $PINS Q=n_26 D=n_92 G=CTS_n11
XA_in_reg[21] DLH_X1 $PINS Q=n_25 D=n_93 G=CTS_n11
XA_in_reg[22] DLH_X1 $PINS Q=n_24 D=n_94 G=CTS_n11
XB_in_reg[0] DLH_X1 $PINS Q=n_0 D=n_96 G=CTS_n11
XB_in_reg[1] DLH_X1 $PINS Q=n_23 D=n_97 G=CTS_n11
XB_in_reg[2] DLH_X1 $PINS Q=n_22 D=n_98 G=CTS_n11
XB_in_reg[3] DLH_X1 $PINS Q=n_21 D=n_99 G=CTS_n11
XB_in_reg[4] DLH_X1 $PINS Q=n_20 D=n_100 G=CTS_n11
XB_in_reg[5] DLH_X1 $PINS Q=n_19 D=n_101 G=CTS_n11
XB_in_reg[6] DLH_X1 $PINS Q=n_18 D=n_102 G=CTS_n11
XB_in_reg[7] DLH_X1 $PINS Q=n_17 D=n_103 G=CTS_n11
XB_in_reg[8] DLH_X1 $PINS Q=n_16 D=n_104 G=CTS_n11
XB_in_reg[9] DLH_X1 $PINS Q=n_15 D=n_105 G=CTS_n11
XB_in_reg[10] DLH_X1 $PINS Q=n_14 D=n_106 G=CTS_n11
XB_in_reg[11] DLH_X1 $PINS Q=n_13 D=n_107 G=CTS_n11
XB_in_reg[12] DLH_X1 $PINS Q=n_12 D=n_108 G=CTS_n11
XB_in_reg[13] DLH_X1 $PINS Q=n_11 D=n_109 G=CTS_n11
XB_in_reg[14] DLH_X1 $PINS Q=n_10 D=n_110 G=CTS_n11
XB_in_reg[15] DLH_X1 $PINS Q=n_9 D=n_111 G=CTS_n11
XB_in_reg[16] DLH_X1 $PINS Q=n_8 D=n_112 G=CTS_n11
XB_in_reg[17] DLH_X1 $PINS Q=n_7 D=n_113 G=CTS_n11
XB_in_reg[18] DLH_X1 $PINS Q=n_6 D=n_114 G=CTS_n11
XB_in_reg[19] DLH_X1 $PINS Q=n_5 D=n_115 G=CTS_n11
XB_in_reg[20] DLH_X1 $PINS Q=n_4 D=n_116 G=CTS_n11
XB_in_reg[21] DLH_X1 $PINS Q=n_3 D=n_117 G=CTS_n11
XB_in_reg[22] DLH_X1 $PINS Q=n_2 D=n_118 G=CTS_n11
XRes_reg[23] DLH_X1 $PINS Q=Res[23] D=n_47 G=n_119
XRes_reg[24] DLH_X1 $PINS Q=Res[24] D=n_48 G=n_119
XRes_reg[25] DLH_X1 $PINS Q=Res[25] D=n_49 G=n_119
XRes_reg[26] DLH_X1 $PINS Q=Res[26] D=n_50 G=n_119
XRes_reg[27] DLH_X1 $PINS Q=Res[27] D=n_51 G=n_119
XRes_reg[28] DLH_X1 $PINS Q=Res[28] D=n_52 G=n_119
XRes_reg[29] DLH_X1 $PINS Q=Res[29] D=n_53 G=n_119
XRes_reg[30] DLH_X1 $PINS Q=Res[30] D=n_54 G=n_119
XRes_reg[31] DLH_X1 $PINS Q=Res[31] D=n_55 G=n_119
XRes_reg[32] DLH_X1 $PINS Q=Res[32] D=n_56 G=n_119
XRes_reg[33] DLH_X1 $PINS Q=Res[33] D=n_57 G=n_119
XRes_reg[34] DLH_X1 $PINS Q=Res[34] D=n_58 G=n_119
XRes_reg[35] DLH_X1 $PINS Q=Res[35] D=n_59 G=n_119
XRes_reg[36] DLH_X1 $PINS Q=Res[36] D=n_60 G=n_119
XRes_reg[37] DLH_X1 $PINS Q=Res[37] D=n_61 G=n_119
XRes_reg[38] DLH_X1 $PINS Q=Res[38] D=n_62 G=n_119
XRes_reg[39] DLH_X1 $PINS Q=Res[39] D=n_63 G=n_119
XRes_reg[40] DLH_X1 $PINS Q=Res[40] D=n_64 G=n_119
XRes_reg[41] DLH_X1 $PINS Q=Res[41] D=n_65 G=n_119
XRes_reg[42] DLH_X1 $PINS Q=Res[42] D=n_66 G=n_119
XRes_reg[43] DLH_X1 $PINS Q=Res[43] D=n_67 G=n_119
XRes_reg[44] DLH_X1 $PINS Q=Res[44] D=n_68 G=n_119
XRes_reg[45] DLH_X1 $PINS Q=Res[45] D=n_69 G=n_119
XRes_reg[46] DLH_X1 $PINS Q=Res[46] D=n_70 G=n_119
XRes_reg[47] DLH_X1 $PINS Q=Res[47] D=n_71 G=n_119
Xi_4 datapath__0_2 $PINS Res_imm[63]=uc_17 Res_imm[62]=uc_18 Res_imm[61]=uc_19
+ Res_imm[60]=uc_20 Res_imm[59]=uc_21 Res_imm[58]=uc_22 Res_imm[57]=uc_23
+ Res_imm[56]=uc_24 Res_imm[55]=uc_25 Res_imm[54]=uc_26 Res_imm[53]=uc_27
+ Res_imm[52]=uc_28 Res_imm[51]=uc_29 Res_imm[50]=uc_30 Res_imm[49]=uc_31
+ Res_imm[48]=uc_32 Res_imm[47]=Res_imm[47] Res_imm[46]=Res_imm[46]
+ Res_imm[45]=Res_imm[45] Res_imm[44]=Res_imm[44] Res_imm[43]=Res_imm[43]
+ Res_imm[42]=Res_imm[42] Res_imm[41]=Res_imm[41] Res_imm[40]=Res_imm[40]
+ Res_imm[39]=Res_imm[39] Res_imm[38]=Res_imm[38] Res_imm[37]=Res_imm[37]
+ Res_imm[36]=Res_imm[36] Res_imm[35]=Res_imm[35] Res_imm[34]=Res_imm[34]
+ Res_imm[33]=Res_imm[33] Res_imm[32]=Res_imm[32] Res_imm[31]=Res_imm[31]
+ Res_imm[30]=Res_imm[30] Res_imm[29]=Res_imm[29] Res_imm[28]=Res_imm[28]
+ Res_imm[27]=Res_imm[27] Res_imm[26]=Res_imm[26] Res_imm[25]=Res_imm[25]
+ Res_imm[24]=Res_imm[24] Res_imm[23]=Res_imm[23] Res_imm[22]=uc_33
+ Res_imm[21]=uc_34 Res_imm[20]=uc_35 Res_imm[19]=uc_36 Res_imm[18]=uc_37
+ Res_imm[17]=uc_38 Res_imm[16]=uc_39 Res_imm[15]=uc_40 Res_imm[14]=uc_41
+ Res_imm[13]=uc_42 Res_imm[12]=uc_43 Res_imm[11]=uc_44 Res_imm[10]=uc_45
+ Res_imm[9]=uc_46 Res_imm[8]=uc_47 Res_imm[7]=uc_48 Res_imm[6]=uc_49
+ Res_imm[5]=uc_50 Res_imm[4]=uc_51 Res_imm[3]=uc_52 Res_imm[2]=uc_53
+ Res_imm[1]=uc_54 Res_imm[0]=uc_55 A_imm[31]=uc_9 A_imm[30]=uc_10
+ A_imm[29]=uc_11 A_imm[28]=uc_12 A_imm[27]=uc_13 A_imm[26]=uc_14 A_imm[25]=uc_15
+ A_imm[24]=uc_16 A_imm[23]=n_46 A_imm[22]=n_24 A_imm[21]=n_25 A_imm[20]=n_26
+ A_imm[19]=n_27 A_imm[18]=n_28 A_imm[17]=n_29 A_imm[16]=n_30 A_imm[15]=n_31
+ A_imm[14]=n_32 A_imm[13]=n_33 A_imm[12]=n_34 A_imm[11]=n_35 A_imm[10]=n_36
+ A_imm[9]=n_37 A_imm[8]=n_38 A_imm[7]=n_39 A_imm[6]=n_40 A_imm[5]=n_41
+ A_imm[4]=n_42 A_imm[3]=n_43 A_imm[2]=n_44 A_imm[1]=n_45 A_imm[0]=n_1
+ B_imm[31]=uc_0 B_imm[30]=uc_1 B_imm[29]=uc_2 B_imm[28]=uc_3 B_imm[27]=uc_4
+ B_imm[26]=uc_5 B_imm[25]=uc_6 B_imm[24]=uc_7 B_imm[23]=uc_8 B_imm[22]=n_2
+ B_imm[21]=n_3 B_imm[20]=n_4 B_imm[19]=n_5 B_imm[18]=n_6 B_imm[17]=n_7
+ B_imm[16]=n_8 B_imm[15]=n_9 B_imm[14]=n_10 B_imm[13]=n_11 B_imm[12]=n_12
+ B_imm[11]=n_13 B_imm[10]=n_14 B_imm[9]=n_15 B_imm[8]=n_16 B_imm[7]=n_17
+ B_imm[6]=n_18 B_imm[5]=n_19 B_imm[4]=n_20 B_imm[3]=n_21 B_imm[2]=n_22
+ B_imm[1]=n_23 B_imm[0]=n_0
XCTS_L2_c_tid1_41 CLKBUF_X3 $PINS Z=clk_CTS_1_PP_4 A=clk_CTS_1_PP_5
Xhfn_ipo_c6 CLKBUF_X3 $PINS Z=hfn_ipo_n6 A=n_0_0__1
XCTS_L1_c_tid1_42 CLKBUF_X1 $PINS Z=clk_CTS_1_PP_5 A=clk_CTS_1_PP_6
.ENDS

.SUBCKT FPU_VM Res[31] Res[30] Res[29] Res[28] Res[27] Res[26] Res[25] Res[24]
+ Res[23] Res[22] Res[21] Res[20] Res[19] Res[18] Res[17] Res[16] Res[15]
+ Res[14] Res[13] Res[12] Res[11] Res[10] Res[9] Res[8] Res[7] Res[6] Res[5]
+ Res[4] Res[3] Res[2] Res[1] Res[0] A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] clk reset enable
Xi_0_1_196 NOR2_X1 $PINS ZN=n_0_1_104 A1=B_reg A2=A_reg
Xi_0_1_124 AOI211_X1 $PINS ZN=n_0_102 A=reset B=n_0_1_104 C1=B_reg C2=A_reg
XCTS_L3_c_tid1_15 CLKBUF_X3 $PINS Z=CTS_n_tid1_13 A=CTS_n_tid1_14
Xi_0_1_122 AND4_X1 $PINS ZN=n_0_1_102 A1=EB[5] A2=EB[4] A3=EB[3] A4=EB[0]
Xi_0_1_121 AND3_X1 $PINS ZN=n_0_1_101 A1=EB[2] A2=EB[1] A3=n_0_1_102
Xi_0_1_120 NAND3_X1 $PINS ZN=n_0_1_100 A1=EB[7] A2=n_0_1_101 A3=EB[6]
Xi_0_1_119 AND4_X1 $PINS ZN=n_0_1_99 A1=EA[5] A2=EA[4] A3=EA[3] A4=EA[0]
Xi_0_1_118 AND3_X1 $PINS ZN=n_0_1_98 A1=EA[2] A2=EA[1] A3=n_0_1_99
Xi_0_1_117 NAND3_X1 $PINS ZN=n_0_1_97 A1=EA[7] A2=n_0_1_98 A3=EA[6]
Xi_0_1_116 OR4_X1 $PINS ZN=n_0_1_96 A1=EA[3] A2=EA[2] A3=EA[1] A4=EA[0]
Xi_0_1_115 OR2_X1 $PINS ZN=n_0_1_95 A1=EA[7] A2=EA[6]
Xi_0_1_114 OR4_X1 $PINS ZN=n_0_1_94 A1=n_0_1_96 A2=n_0_1_95 A3=EA[5] A4=EA[4]
Xi_0_1_113 OR4_X1 $PINS ZN=n_0_1_93 A1=EB[3] A2=EB[2] A3=EB[1] A4=EB[0]
Xi_0_1_112 OR2_X1 $PINS ZN=n_0_1_92 A1=EB[7] A2=EB[6]
Xi_0_1_111 OR4_X1 $PINS ZN=n_0_1_91 A1=n_0_1_93 A2=n_0_1_92 A3=EB[5] A4=EB[4]
Xi_0_1_110 OAI22_X1 $PINS ZN=n_0_1_90 A1=n_0_1_100 A2=n_0_1_94 B1=n_0_1_97
+ B2=n_0_1_91
Xi_0_1_109 INV_X1 $PINS ZN=n_0_1_89 A=n_0_1_90
Xi_0_1_108 NOR4_X1 $PINS ZN=n_0_1_88 A1=n_0_52 A2=n_0_53 A3=n_0_54 A4=n_0_55
Xi_0_1_107 NOR4_X1 $PINS ZN=n_0_1_87 A1=n_0_48 A2=n_0_49 A3=n_0_50 A4=n_0_51
Xi_0_1_106 NOR4_X1 $PINS ZN=n_0_1_86 A1=n_0_61 A2=n_0_62 A3=n_0_56 A4=n_0_59
Xi_0_1_105 NOR3_X1 $PINS ZN=n_0_1_85 A1=n_0_65 A2=n_0_66 A3=n_0_69
Xi_0_1_104 NOR4_X1 $PINS ZN=n_0_1_84 A1=n_0_60 A2=n_0_63 A3=n_0_57 A4=n_0_58
Xi_0_1_103 NOR4_X1 $PINS ZN=n_0_1_83 A1=n_0_68 A2=n_0_70 A3=n_0_64 A4=n_0_67
Xi_0_1_102 AND4_X1 $PINS ZN=n_0_1_82 A1=n_0_1_88 A2=n_0_1_87 A3=n_0_1_84
+ A4=n_0_1_83
Xi_0_1_101 NAND3_X1 $PINS ZN=n_0_1_81 A1=n_0_1_86 A2=n_0_1_85 A3=n_0_1_82
Xi_0_1_100 NOR4_X1 $PINS ZN=n_0_1_80 A1=n_0_29 A2=n_0_30 A3=n_0_31 A4=n_0_32
Xi_0_1_99 NOR4_X1 $PINS ZN=n_0_1_79 A1=n_0_25 A2=n_0_26 A3=n_0_27 A4=n_0_28
Xi_0_1_98 NOR4_X1 $PINS ZN=n_0_1_78 A1=n_0_38 A2=n_0_39 A3=n_0_33 A4=n_0_36
Xi_0_1_97 NOR3_X1 $PINS ZN=n_0_1_77 A1=n_0_42 A2=n_0_43 A3=n_0_46
Xi_0_1_96 NOR4_X1 $PINS ZN=n_0_1_76 A1=n_0_37 A2=n_0_40 A3=n_0_34 A4=n_0_35
Xi_0_1_95 NOR4_X1 $PINS ZN=n_0_1_75 A1=n_0_45 A2=n_0_47 A3=n_0_41 A4=n_0_44
Xi_0_1_94 AND4_X1 $PINS ZN=n_0_1_74 A1=n_0_1_80 A2=n_0_1_79 A3=n_0_1_76
+ A4=n_0_1_75
Xi_0_1_93 NAND3_X1 $PINS ZN=n_0_1_73 A1=n_0_1_78 A2=n_0_1_77 A3=n_0_1_74
Xi_0_1_92 NOR4_X1 $PINS ZN=n_0_1_72 A1=reset A2=n_0_1_73 A3=n_0_1_81
+ A4=n_0_1_89
Xi_0_1_91 INV_X1 $PINS ZN=n_0_1_71 A=n_0_1_72
Xi_0_1_90 OAI22_X1 $PINS ZN=n_0_1_70 A1=n_0_1_91 A2=n_0_1_81 B1=n_0_1_94
+ B2=n_0_1_73
Xi_0_1_89 NOR2_X1 $PINS ZN=n_0_1_69 A1=reset A2=n_0_1_70
Xi_0_1_88 AND2_X1 $PINS ZN=n_0_1_68 A1=EA[7] A2=EB[7]
Xi_0_1_87 OAI221_X1 $PINS ZN=n_0_1_67 A=n_0_1_68 B1=EA[6] B2=n_0_1_98 C1=EB[6]
+ C2=n_0_1_101
Xi_0_1_86 OR4_X1 $PINS ZN=n_0_1_66 A1=n_0_1_101 A2=n_0_1_98 A3=n_0_1_92
+ A4=n_0_1_95
Xi_0_1_85 AOI22_X1 $PINS ZN=n_0_1_65 A1=n_0_1_29 A2=n_0_0 B1=n_0_24
+ B2=M_resultTruncated[0]
Xi_0_1_84 NAND2_X1 $PINS ZN=n_0_1_63 A1=n_0_1_67 A2=n_0_1_66
Xi_0_1_83 OAI211_X1 $PINS ZN=n_0_1_61 A=n_0_1_100 B=n_0_1_97 C1=n_0_1_65
+ C2=n_0_1_63
Xi_0_1_82 INV_X1 $PINS ZN=n_0_1_31 A=n_0_1_61
Xi_0_1_81 OAI221_X1 $PINS ZN=n_0_1_30 A=n_0_1_69 B1=n_0_1_100 B2=n_0_1_81
+ C1=n_0_1_97 C2=n_0_1_73
Xi_0_1_80 OAI21_X1 $PINS ZN=n_0_71 A=n_0_1_71 B1=n_0_1_31 B2=n_0_1_30
Xi_0_1_79 INV_X1 $PINS ZN=n_0_1_29 A=n_0_24
Xi_0_1_198 INV_X1 $PINS ZN=n_0_1_28 A=enable
Xi_0_1_78 INV_X1 $PINS ZN=n_0_1_112 A=reset
Xi_0_1_66 INV_X1 $PINS ZN=n_0_1_111 A=n_0_1_14
Xi_0_1_195 INV_X1 $PINS ZN=n_0_1_110 A=n_0_1_22
Xi_0_1_194 INV_X1 $PINS ZN=n_0_1_109 A=n_0_1_23
Xi_0_1_193 INV_X1 $PINS ZN=n_0_1_108 A=n_0_1_24
Xi_0_1_192 INV_X1 $PINS ZN=n_0_1_107 A=n_0_1_25
Xi_0_1_191 INV_X1 $PINS ZN=n_0_1_106 A=n_0_1_26
Xi_0_1_190 INV_X1 $PINS ZN=n_0_1_105 A=n_0_1_27
Xi_0_1_189 OR2_X2 $PINS ZN=n_0_168 A1=CTS_n_tid1_90 A2=reset
Xi_0_1_188 AND2_X1 $PINS ZN=CLOCK_slh__n226 A1=hfn_ipo_n11 A2=B[30]
Xi_0_1_187 AND2_X1 $PINS ZN=CLOCK_slh__n258 A1=hfn_ipo_n11 A2=B[29]
Xi_0_1_186 AND2_X1 $PINS ZN=CLOCK_slh__n234 A1=hfn_ipo_n11 A2=B[28]
Xi_0_1_185 AND2_X1 $PINS ZN=CLOCK_slh__n222 A1=hfn_ipo_n11 A2=B[27]
Xi_0_1_184 AND2_X1 $PINS ZN=CLOCK_slh__n218 A1=hfn_ipo_n11 A2=B[26]
Xi_0_1_183 AND2_X1 $PINS ZN=CLOCK_slh__n214 A1=hfn_ipo_n11 A2=B[25]
Xi_0_1_182 AND2_X1 $PINS ZN=CLOCK_slh__n178 A1=hfn_ipo_n11 A2=B[24]
Xi_0_1_181 AND2_X1 $PINS ZN=CLOCK_slh__n378 A1=hfn_ipo_n11 A2=B[23]
Xi_0_1_180 AND2_X1 $PINS ZN=CLOCK_slh__n294 A1=hfn_ipo_n11 A2=B[22]
Xi_0_1_179 AND2_X1 $PINS ZN=CLOCK_slh__n314 A1=hfn_ipo_n11 A2=B[21]
Xi_0_1_178 AND2_X1 $PINS ZN=CLOCK_slh__n322 A1=hfn_ipo_n11 A2=B[20]
Xi_0_1_177 AND2_X1 $PINS ZN=CLOCK_slh__n290 A1=hfn_ipo_n11 A2=B[19]
Xi_0_1_176 AND2_X1 $PINS ZN=CLOCK_slh__n254 A1=hfn_ipo_n10 A2=B[18]
Xi_0_1_175 AND2_X1 $PINS ZN=CLOCK_slh__n358 A1=hfn_ipo_n10 A2=B[17]
Xi_0_1_174 AND2_X1 $PINS ZN=CLOCK_slh__n270 A1=hfn_ipo_n10 A2=B[16]
Xi_0_1_173 AND2_X1 $PINS ZN=CLOCK_slh__n350 A1=hfn_ipo_n10 A2=B[15]
Xi_0_1_172 AND2_X1 $PINS ZN=CLOCK_slh__n342 A1=hfn_ipo_n10 A2=B[14]
Xi_0_1_171 AND2_X1 $PINS ZN=CLOCK_slh__n354 A1=hfn_ipo_n10 A2=B[13]
Xi_0_1_170 AND2_X1 $PINS ZN=CLOCK_slh__n278 A1=hfn_ipo_n10 A2=B[12]
Xi_0_1_169 AND2_X1 $PINS ZN=CLOCK_slh__n382 A1=hfn_ipo_n10 A2=B[11]
Xi_0_1_168 AND2_X1 $PINS ZN=CLOCK_slh__n246 A1=hfn_ipo_n10 A2=B[10]
Xi_0_1_167 AND2_X1 $PINS ZN=CLOCK_slh__n330 A1=hfn_ipo_n10 A2=B[9]
Xi_0_1_166 AND2_X1 $PINS ZN=CLOCK_slh__n286 A1=hfn_ipo_n10 A2=B[8]
Xi_0_1_165 AND2_X1 $PINS ZN=CLOCK_slh__n326 A1=hfn_ipo_n10 A2=B[7]
Xi_0_1_164 AND2_X1 $PINS ZN=CLOCK_slh__n374 A1=hfn_ipo_n10 A2=B[6]
Xi_0_1_163 AND2_X1 $PINS ZN=CLOCK_slh__n302 A1=hfn_ipo_n10 A2=B[5]
Xi_0_1_162 AND2_X1 $PINS ZN=CLOCK_slh__n298 A1=hfn_ipo_n10 A2=B[4]
Xi_0_1_161 AND2_X1 $PINS ZN=CLOCK_slh__n242 A1=hfn_ipo_n10 A2=B[3]
Xi_0_1_160 AND2_X1 $PINS ZN=CLOCK_slh__n318 A1=hfn_ipo_n10 A2=B[2]
Xi_0_1_159 AND2_X1 $PINS ZN=CLOCK_slh__n334 A1=hfn_ipo_n10 A2=B[1]
Xi_0_1_158 AND2_X1 $PINS ZN=CLOCK_slh__n370 A1=hfn_ipo_n10 A2=B[0]
Xi_0_1_157 AND2_X1 $PINS ZN=CLOCK_slh__n190 A1=hfn_ipo_n11 A2=A[30]
Xi_0_1_156 AND2_X1 $PINS ZN=CLOCK_slh__n282 A1=hfn_ipo_n11 A2=A[29]
Xi_0_1_155 AND2_X1 $PINS ZN=CLOCK_slh__n210 A1=hfn_ipo_n11 A2=A[28]
Xi_0_1_154 AND2_X1 $PINS ZN=CLOCK_slh__n186 A1=hfn_ipo_n11 A2=A[27]
Xi_0_1_153 AND2_X1 $PINS ZN=CLOCK_slh__n206 A1=hfn_ipo_n11 A2=A[26]
Xi_0_1_152 AND2_X1 $PINS ZN=CLOCK_slh__n202 A1=hfn_ipo_n11 A2=A[25]
Xi_0_1_151 AND2_X1 $PINS ZN=CLOCK_slh__n198 A1=hfn_ipo_n11 A2=A[24]
Xi_0_1_150 AND2_X1 $PINS ZN=CLOCK_slh__n182 A1=hfn_ipo_n11 A2=A[23]
Xi_0_1_149 AND2_X1 $PINS ZN=CLOCK_slh__n388 A1=hfn_ipo_n11 A2=A[22]
Xi_0_1_148 AND2_X1 $PINS ZN=CLOCK_slh__n338 A1=hfn_ipo_n11 A2=A[21]
Xi_0_1_147 AND2_X1 $PINS ZN=CLOCK_slh__n310 A1=hfn_ipo_n11 A2=A[20]
Xi_0_1_146 AND2_X1 $PINS ZN=CLOCK_slh__n306 A1=hfn_ipo_n11 A2=A[19]
Xi_0_1_145 AND2_X1 $PINS ZN=CLOCK_slh__n394 A1=hfn_ipo_n10 A2=A[18]
Xi_0_1_144 AND2_X1 $PINS ZN=CLOCK_slh__n346 A1=hfn_ipo_n11 A2=A[17]
Xi_0_1_143 AND2_X1 $PINS ZN=CLOCK_slh__n398 A1=hfn_ipo_n10 A2=A[16]
Xi_0_1_142 AND2_X1 $PINS ZN=CLOCK_slh__n266 A1=hfn_ipo_n10 A2=A[15]
Xi_0_1_141 AND2_X1 $PINS ZN=CLOCK_slh__n396 A1=hfn_ipo_n11 A2=A[14]
Xi_0_1_140 AND2_X1 $PINS ZN=CLOCK_slh__n392 A1=hfn_ipo_n11 A2=A[13]
Xi_0_1_139 AND2_X1 $PINS ZN=CLOCK_slh__n408 A1=hfn_ipo_n10 A2=A[12]
Xi_0_1_138 AND2_X1 $PINS ZN=CLOCK_slh__n406 A1=hfn_ipo_n10 A2=A[11]
Xi_0_1_137 AND2_X1 $PINS ZN=CLOCK_slh__n404 A1=hfn_ipo_n11 A2=A[10]
Xi_0_1_136 AND2_X1 $PINS ZN=CLOCK_slh__n402 A1=hfn_ipo_n10 A2=A[9]
Xi_0_1_135 AND2_X1 $PINS ZN=CLOCK_slh__n400 A1=hfn_ipo_n11 A2=A[8]
Xi_0_1_134 AND2_X1 $PINS ZN=CLOCK_slh__n262 A1=hfn_ipo_n10 A2=A[7]
Xi_0_1_133 AND2_X1 $PINS ZN=CLOCK_slh__n386 A1=hfn_ipo_n10 A2=A[6]
Xi_0_1_132 AND2_X1 $PINS ZN=CLOCK_slh__n238 A1=hfn_ipo_n10 A2=A[5]
Xi_0_1_131 AND2_X1 $PINS ZN=CLOCK_slh__n250 A1=hfn_ipo_n10 A2=A[4]
Xi_0_1_130 AND2_X1 $PINS ZN=CLOCK_slh__n366 A1=hfn_ipo_n10 A2=A[3]
Xi_0_1_129 AND2_X1 $PINS ZN=CLOCK_slh__n362 A1=hfn_ipo_n10 A2=A[2]
Xi_0_1_128 AND2_X1 $PINS ZN=CLOCK_slh__n274 A1=hfn_ipo_n10 A2=A[1]
Xi_0_1_127 AND2_X1 $PINS ZN=CLOCK_slh__n390 A1=hfn_ipo_n10 A2=A[0]
Xi_0_1_126 AND2_X1 $PINS ZN=CLOCK_slh__n194 A1=hfn_ipo_n11 A2=B[31]
Xi_0_1_125 OAI21_X4 $PINS ZN=CTS_n_tid1_14 A=hfn_ipo_n11 B1=n_0_1_28
+ B2=CTS_n_tid1_91
Xi_0_1_65 AND2_X1 $PINS ZN=CLOCK_slh__n230 A1=hfn_ipo_n11 A2=A[31]
Xi_0_1_64 NAND3_X1 $PINS ZN=n_0_1_64 A1=n_0_1_100 A2=n_0_1_97 A3=n_0_1_67
Xi_0_1_21 AOI21_X1 $PINS ZN=n_0_1_62 A=n_0_1_72 B1=n_0_1_69 B2=n_0_1_64
Xi_0_1_20 NAND2_X1 $PINS ZN=n_0_1_60 A1=n_0_1_69 A2=n_0_1_66
Xi_0_1_77 NOR2_X1 $PINS ZN=n_0_1_59 A1=EB[7] A2=EA[7]
Xi_0_1_76 NOR2_X1 $PINS ZN=n_0_1_58 A1=n_0_1_68 A2=n_0_1_59
Xi_0_1_75 XNOR2_X1 $PINS ZN=n_0_1_57 A=n_0_1_13 B=n_0_1_21
Xi_0_1_74 XNOR2_X1 $PINS ZN=n_0_1_56 A=n_0_1_58 B=n_0_1_57
Xi_0_1_73 OAI21_X1 $PINS ZN=n_0_101 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_56
Xi_0_1_72 OAI21_X1 $PINS ZN=n_0_100 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_105
Xi_0_1_71 OAI21_X1 $PINS ZN=n_0_99 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_106
Xi_0_1_70 OAI21_X1 $PINS ZN=n_0_98 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_107
Xi_0_1_69 OAI21_X1 $PINS ZN=n_0_97 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_108
Xi_0_1_68 OAI21_X1 $PINS ZN=n_0_96 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_109
Xi_0_1_67 OAI21_X1 $PINS ZN=n_0_95 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_110
Xi_0_1_19 OAI21_X1 $PINS ZN=n_0_94 A=n_0_1_62 B1=n_0_1_60 B2=n_0_1_111
Xi_0_1_18 NOR3_X4 $PINS ZN=n_0_1_55 A1=n_0_1_29 A2=n_0_1_64 A3=n_0_1_60
Xi_0_1_17 NOR3_X4 $PINS ZN=n_0_1_54 A1=n_0_1_60 A2=n_0_24 A3=n_0_1_64
Xi_0_1_63 AOI22_X1 $PINS ZN=n_0_1_53 A1=M_resultTruncated[22] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_22
Xi_0_1_62 INV_X1 $PINS ZN=n_0_93 A=n_0_1_53
Xi_0_1_61 AOI22_X1 $PINS ZN=n_0_1_52 A1=M_resultTruncated[21] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_21
Xi_0_1_60 INV_X1 $PINS ZN=n_0_92 A=n_0_1_52
Xi_0_1_59 AOI22_X1 $PINS ZN=n_0_1_51 A1=M_resultTruncated[20] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_20
Xi_0_1_58 INV_X1 $PINS ZN=n_0_91 A=n_0_1_51
Xi_0_1_57 AOI22_X1 $PINS ZN=n_0_1_50 A1=M_resultTruncated[19] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_19
Xi_0_1_56 INV_X1 $PINS ZN=n_0_90 A=n_0_1_50
Xi_0_1_55 AOI22_X1 $PINS ZN=n_0_1_49 A1=M_resultTruncated[18] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_18
Xi_0_1_54 INV_X1 $PINS ZN=n_0_89 A=n_0_1_49
Xi_0_1_53 AOI22_X1 $PINS ZN=n_0_1_48 A1=M_resultTruncated[17] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_17
Xi_0_1_52 INV_X1 $PINS ZN=n_0_88 A=n_0_1_48
Xi_0_1_51 AOI22_X1 $PINS ZN=n_0_1_47 A1=M_resultTruncated[16] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_16
Xi_0_1_50 INV_X1 $PINS ZN=n_0_87 A=n_0_1_47
Xi_0_1_49 AOI22_X1 $PINS ZN=n_0_1_46 A1=M_resultTruncated[15] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_15
Xi_0_1_48 INV_X1 $PINS ZN=n_0_86 A=n_0_1_46
Xi_0_1_47 AOI22_X1 $PINS ZN=n_0_1_45 A1=M_resultTruncated[14] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_14
Xi_0_1_46 INV_X1 $PINS ZN=n_0_85 A=n_0_1_45
Xi_0_1_45 AOI22_X1 $PINS ZN=n_0_1_44 A1=M_resultTruncated[13] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_13
Xi_0_1_44 INV_X1 $PINS ZN=n_0_84 A=n_0_1_44
Xi_0_1_43 AOI22_X1 $PINS ZN=n_0_1_43 A1=M_resultTruncated[12] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_12
Xi_0_1_42 INV_X1 $PINS ZN=n_0_83 A=n_0_1_43
Xi_0_1_41 AOI22_X1 $PINS ZN=n_0_1_42 A1=M_resultTruncated[11] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_11
Xi_0_1_40 INV_X1 $PINS ZN=n_0_82 A=n_0_1_42
Xi_0_1_39 AOI22_X1 $PINS ZN=n_0_1_41 A1=M_resultTruncated[10] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_10
Xi_0_1_38 INV_X1 $PINS ZN=n_0_81 A=n_0_1_41
Xi_0_1_37 AOI22_X1 $PINS ZN=n_0_1_40 A1=M_resultTruncated[9] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_9
Xi_0_1_36 INV_X1 $PINS ZN=n_0_80 A=n_0_1_40
Xi_0_1_35 AOI22_X1 $PINS ZN=n_0_1_39 A1=M_resultTruncated[8] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_8
Xi_0_1_34 INV_X1 $PINS ZN=n_0_79 A=n_0_1_39
Xi_0_1_33 AOI22_X1 $PINS ZN=n_0_1_38 A1=M_resultTruncated[7] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_7
Xi_0_1_32 INV_X1 $PINS ZN=n_0_78 A=n_0_1_38
Xi_0_1_31 AOI22_X1 $PINS ZN=n_0_1_37 A1=M_resultTruncated[6] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_6
Xi_0_1_30 INV_X1 $PINS ZN=n_0_77 A=n_0_1_37
Xi_0_1_29 AOI22_X1 $PINS ZN=n_0_1_36 A1=M_resultTruncated[5] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_5
Xi_0_1_28 INV_X1 $PINS ZN=n_0_76 A=n_0_1_36
Xi_0_1_27 AOI22_X1 $PINS ZN=n_0_1_35 A1=M_resultTruncated[4] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_4
Xi_0_1_26 INV_X1 $PINS ZN=n_0_75 A=n_0_1_35
Xi_0_1_25 AOI22_X1 $PINS ZN=n_0_1_34 A1=M_resultTruncated[3] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_3
Xi_0_1_24 INV_X1 $PINS ZN=n_0_74 A=n_0_1_34
Xi_0_1_23 AOI22_X1 $PINS ZN=n_0_1_33 A1=M_resultTruncated[2] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_2
Xi_0_1_22 INV_X1 $PINS ZN=n_0_73 A=n_0_1_33
Xi_0_1_16 AOI22_X1 $PINS ZN=n_0_1_32 A1=M_resultTruncated[1] A2=n_0_1_55
+ B1=n_0_1_54 B2=n_0_1
Xi_0_1_15 INV_X1 $PINS ZN=n_0_72 A=n_0_1_32
Xi_0_1_14 OR2_X1 $PINS ZN=n_0_1_1 A1=EB[0] A2=n_0_24
Xi_0_1_13 XNOR2_X1 $PINS ZN=n_0_1_0 A=EB[0] B=n_0_24
Xi_0_1_12 FA_X1 $PINS CO=n_0_1_21 S=n_0_1_27 A=n_0_1_11 B=n_0_1_12 CI=n_0_1_20
Xi_0_1_11 FA_X1 $PINS CO=n_0_1_20 S=n_0_1_26 A=n_0_1_9 B=n_0_1_10 CI=n_0_1_19
Xi_0_1_10 FA_X1 $PINS CO=n_0_1_19 S=n_0_1_25 A=n_0_1_7 B=n_0_1_8 CI=n_0_1_18
Xi_0_1_9 FA_X1 $PINS CO=n_0_1_18 S=n_0_1_24 A=n_0_1_5 B=n_0_1_6 CI=n_0_1_17
Xi_0_1_8 FA_X1 $PINS CO=n_0_1_17 S=n_0_1_23 A=n_0_1_3 B=n_0_1_4 CI=n_0_1_16
Xi_0_1_7 FA_X1 $PINS CO=n_0_1_16 S=n_0_1_22 A=n_0_1_1 B=n_0_1_2 CI=n_0_1_15
Xi_0_1_6 HA_X1 $PINS CO=n_0_1_15 S=n_0_1_14 A=EA[0] B=n_0_1_0
Xi_0_1_5 HA_X1 $PINS CO=n_0_1_13 S=n_0_1_12 A=EB[6] B=EA[6]
Xi_0_1_4 HA_X1 $PINS CO=n_0_1_11 S=n_0_1_10 A=EB[5] B=EA[5]
Xi_0_1_3 HA_X1 $PINS CO=n_0_1_9 S=n_0_1_8 A=EB[4] B=EA[4]
Xi_0_1_2 HA_X1 $PINS CO=n_0_1_7 S=n_0_1_6 A=EB[3] B=EA[3]
Xi_0_1_1 HA_X1 $PINS CO=n_0_1_5 S=n_0_1_4 A=EB[2] B=EA[2]
Xi_0_1_0 HA_X1 $PINS CO=n_0_1_3 S=n_0_1_2 A=EB[1] B=EA[1]
XB_reg_reg[31] DLH_X1 $PINS Q=B_reg D=n_0_105 G=CTS_n_tid1_13
XA_reg_reg[31] DLH_X1 $PINS Q=A_reg D=n_0_103 G=CTS_n_tid1_13
XB_reg_reg[0] DLH_X1 $PINS Q=n_0_70 D=n_0_137 G=CTS_n_tid1_13
XB_reg_reg[1] DLH_X1 $PINS Q=n_0_69 D=n_0_138 G=CTS_n_tid1_13
XB_reg_reg[2] DLH_X1 $PINS Q=n_0_68 D=n_0_139 G=CTS_n_tid1_13
XB_reg_reg[3] DLH_X1 $PINS Q=n_0_67 D=n_0_140 G=CTS_n_tid1_13
XB_reg_reg[4] DLH_X1 $PINS Q=n_0_66 D=n_0_141 G=CTS_n_tid1_13
XB_reg_reg[5] DLH_X1 $PINS Q=n_0_65 D=n_0_142 G=CTS_n_tid1_13
XB_reg_reg[6] DLH_X1 $PINS Q=n_0_64 D=n_0_143 G=CTS_n_tid1_13
XB_reg_reg[7] DLH_X1 $PINS Q=n_0_63 D=n_0_144 G=CTS_n_tid1_13
XB_reg_reg[8] DLH_X1 $PINS Q=n_0_62 D=n_0_145 G=CTS_n_tid1_13
XB_reg_reg[9] DLH_X1 $PINS Q=n_0_61 D=n_0_146 G=CTS_n_tid1_13
XB_reg_reg[10] DLH_X1 $PINS Q=n_0_60 D=n_0_147 G=CTS_n_tid1_13
XB_reg_reg[11] DLH_X1 $PINS Q=n_0_59 D=n_0_148 G=CTS_n_tid1_13
XB_reg_reg[12] DLH_X1 $PINS Q=n_0_58 D=n_0_149 G=CTS_n_tid1_13
XB_reg_reg[13] DLH_X1 $PINS Q=n_0_57 D=n_0_150 G=CTS_n_tid1_13
XB_reg_reg[14] DLH_X1 $PINS Q=n_0_56 D=n_0_151 G=CTS_n_tid1_13
XB_reg_reg[15] DLH_X1 $PINS Q=n_0_55 D=n_0_152 G=CTS_n_tid1_13
XB_reg_reg[16] DLH_X1 $PINS Q=n_0_54 D=n_0_153 G=CTS_n_tid1_13
XB_reg_reg[17] DLH_X1 $PINS Q=n_0_53 D=n_0_154 G=CTS_n_tid1_13
XB_reg_reg[18] DLH_X1 $PINS Q=n_0_52 D=n_0_155 G=CTS_n_tid1_13
XB_reg_reg[19] DLH_X1 $PINS Q=n_0_51 D=n_0_156 G=CTS_n_tid1_13
XB_reg_reg[20] DLH_X1 $PINS Q=n_0_50 D=n_0_157 G=CTS_n_tid1_13
XB_reg_reg[21] DLH_X1 $PINS Q=n_0_49 D=n_0_158 G=CTS_n_tid1_13
XB_reg_reg[22] DLH_X1 $PINS Q=n_0_48 D=n_0_159 G=CTS_n_tid1_13
XB_reg_reg[23] DLH_X1 $PINS Q=EB[0] D=n_0_160 G=CTS_n_tid1_13
XB_reg_reg[24] DLH_X1 $PINS Q=EB[1] D=n_0_161 G=CTS_n_tid1_13
XB_reg_reg[25] DLH_X1 $PINS Q=EB[2] D=n_0_162 G=CTS_n_tid1_13
XB_reg_reg[26] DLH_X1 $PINS Q=EB[3] D=n_0_163 G=CTS_n_tid1_13
XB_reg_reg[27] DLH_X1 $PINS Q=EB[4] D=n_0_164 G=CTS_n_tid1_13
XB_reg_reg[28] DLH_X1 $PINS Q=EB[5] D=n_0_165 G=CTS_n_tid1_13
XB_reg_reg[29] DLH_X1 $PINS Q=EB[6] D=n_0_166 G=CTS_n_tid1_13
XB_reg_reg[30] DLH_X1 $PINS Q=EB[7] D=n_0_167 G=CTS_n_tid1_13
XA_reg_reg[0] DLH_X1 $PINS Q=n_0_47 D=n_0_106 G=CTS_n_tid1_13
XA_reg_reg[1] DLH_X1 $PINS Q=n_0_46 D=n_0_107 G=CTS_n_tid1_13
XA_reg_reg[2] DLH_X1 $PINS Q=n_0_45 D=n_0_108 G=CTS_n_tid1_13
XA_reg_reg[3] DLH_X1 $PINS Q=n_0_44 D=n_0_109 G=CTS_n_tid1_13
XA_reg_reg[4] DLH_X1 $PINS Q=n_0_43 D=n_0_110 G=CTS_n_tid1_13
XA_reg_reg[5] DLH_X1 $PINS Q=n_0_42 D=n_0_111 G=CTS_n_tid1_13
XA_reg_reg[6] DLH_X1 $PINS Q=n_0_41 D=n_0_112 G=CTS_n_tid1_13
XA_reg_reg[7] DLH_X1 $PINS Q=n_0_40 D=n_0_113 G=CTS_n_tid1_13
XA_reg_reg[8] DLH_X1 $PINS Q=n_0_39 D=n_0_114 G=CTS_n_tid1_13
XA_reg_reg[9] DLH_X1 $PINS Q=n_0_38 D=n_0_115 G=CTS_n_tid1_13
XA_reg_reg[10] DLH_X1 $PINS Q=n_0_37 D=n_0_116 G=CTS_n_tid1_13
XA_reg_reg[11] DLH_X1 $PINS Q=n_0_36 D=n_0_117 G=CTS_n_tid1_13
XA_reg_reg[12] DLH_X1 $PINS Q=n_0_35 D=n_0_118 G=CTS_n_tid1_13
XA_reg_reg[13] DLH_X1 $PINS Q=n_0_34 D=n_0_119 G=CTS_n_tid1_13
XA_reg_reg[14] DLH_X1 $PINS Q=n_0_33 D=n_0_120 G=CTS_n_tid1_13
XA_reg_reg[15] DLH_X1 $PINS Q=n_0_32 D=n_0_121 G=CTS_n_tid1_13
XA_reg_reg[16] DLH_X1 $PINS Q=n_0_31 D=n_0_122 G=CTS_n_tid1_13
XA_reg_reg[17] DLH_X1 $PINS Q=n_0_30 D=n_0_123 G=CTS_n_tid1_13
XA_reg_reg[18] DLH_X1 $PINS Q=n_0_29 D=n_0_124 G=CTS_n_tid1_13
XA_reg_reg[19] DLH_X1 $PINS Q=n_0_28 D=n_0_125 G=CTS_n_tid1_13
XA_reg_reg[20] DLH_X1 $PINS Q=n_0_27 D=n_0_126 G=CTS_n_tid1_13
XA_reg_reg[21] DLH_X1 $PINS Q=n_0_26 D=n_0_127 G=CTS_n_tid1_13
XA_reg_reg[22] DLH_X1 $PINS Q=n_0_25 D=n_0_128 G=CTS_n_tid1_13
XA_reg_reg[23] DLH_X1 $PINS Q=EA[0] D=n_0_129 G=CTS_n_tid1_13
XA_reg_reg[24] DLH_X1 $PINS Q=EA[1] D=n_0_130 G=CTS_n_tid1_13
XA_reg_reg[25] DLH_X1 $PINS Q=EA[2] D=n_0_131 G=CTS_n_tid1_13
XA_reg_reg[26] DLH_X1 $PINS Q=EA[3] D=n_0_132 G=CTS_n_tid1_13
XA_reg_reg[27] DLH_X1 $PINS Q=EA[4] D=n_0_133 G=CTS_n_tid1_13
XA_reg_reg[28] DLH_X1 $PINS Q=EA[5] D=n_0_134 G=CTS_n_tid1_13
XA_reg_reg[29] DLH_X1 $PINS Q=EA[6] D=n_0_135 G=CTS_n_tid1_13
XA_reg_reg[30] DLH_X1 $PINS Q=EA[7] D=n_0_136 G=CTS_n_tid1_13
XRes_reg[0] DLH_X1 $PINS Q=Res[0] D=n_0_71 G=n_0_168
XRes_reg[1] DLH_X1 $PINS Q=Res[1] D=n_0_72 G=n_0_168
XRes_reg[2] DLH_X1 $PINS Q=Res[2] D=n_0_73 G=n_0_168
XRes_reg[3] DLH_X1 $PINS Q=Res[3] D=n_0_74 G=n_0_168
XRes_reg[4] DLH_X1 $PINS Q=Res[4] D=n_0_75 G=n_0_168
XRes_reg[5] DLH_X1 $PINS Q=Res[5] D=n_0_76 G=n_0_168
XRes_reg[6] DLH_X1 $PINS Q=Res[6] D=n_0_77 G=n_0_168
XRes_reg[7] DLH_X1 $PINS Q=Res[7] D=n_0_78 G=n_0_168
XRes_reg[8] DLH_X1 $PINS Q=Res[8] D=n_0_79 G=n_0_168
XRes_reg[9] DLH_X1 $PINS Q=Res[9] D=n_0_80 G=n_0_168
XRes_reg[10] DLH_X1 $PINS Q=Res[10] D=n_0_81 G=n_0_168
XRes_reg[11] DLH_X1 $PINS Q=Res[11] D=n_0_82 G=n_0_168
XRes_reg[12] DLH_X1 $PINS Q=Res[12] D=n_0_83 G=n_0_168
XRes_reg[13] DLH_X1 $PINS Q=Res[13] D=n_0_84 G=n_0_168
XRes_reg[14] DLH_X1 $PINS Q=Res[14] D=n_0_85 G=n_0_168
XRes_reg[15] DLH_X1 $PINS Q=Res[15] D=n_0_86 G=n_0_168
XRes_reg[16] DLH_X1 $PINS Q=Res[16] D=n_0_87 G=n_0_168
XRes_reg[17] DLH_X1 $PINS Q=Res[17] D=n_0_88 G=n_0_168
XRes_reg[18] DLH_X1 $PINS Q=Res[18] D=n_0_89 G=n_0_168
XRes_reg[19] DLH_X1 $PINS Q=Res[19] D=n_0_90 G=n_0_168
XRes_reg[20] DLH_X1 $PINS Q=Res[20] D=n_0_91 G=n_0_168
XRes_reg[21] DLH_X1 $PINS Q=Res[21] D=n_0_92 G=n_0_168
XRes_reg[22] DLH_X1 $PINS Q=Res[22] D=n_0_93 G=n_0_168
XRes_reg[23] DLH_X1 $PINS Q=Res[23] D=n_0_94 G=n_0_168
XRes_reg[24] DLH_X1 $PINS Q=Res[24] D=n_0_95 G=n_0_168
XRes_reg[25] DLH_X1 $PINS Q=Res[25] D=n_0_96 G=n_0_168
XRes_reg[26] DLH_X1 $PINS Q=Res[26] D=n_0_97 G=n_0_168
XRes_reg[27] DLH_X1 $PINS Q=Res[27] D=n_0_98 G=n_0_168
XRes_reg[28] DLH_X1 $PINS Q=Res[28] D=n_0_99 G=n_0_168
XRes_reg[29] DLH_X1 $PINS Q=Res[29] D=n_0_100 G=n_0_168
XRes_reg[30] DLH_X1 $PINS Q=Res[30] D=n_0_101 G=n_0_168
XRes_reg[31] DLH_X1 $PINS Q=Res[31] D=n_0_102 G=n_0_168
Xi_0_0 datapath__0_13 $PINS M_resultTruncated[22]=M_resultTruncated[22]
+ M_resultTruncated[21]=M_resultTruncated[21]
+ M_resultTruncated[20]=M_resultTruncated[20]
+ M_resultTruncated[19]=M_resultTruncated[19]
+ M_resultTruncated[18]=M_resultTruncated[18]
+ M_resultTruncated[17]=M_resultTruncated[17]
+ M_resultTruncated[16]=M_resultTruncated[16]
+ M_resultTruncated[15]=M_resultTruncated[15]
+ M_resultTruncated[14]=M_resultTruncated[14]
+ M_resultTruncated[13]=M_resultTruncated[13]
+ M_resultTruncated[12]=M_resultTruncated[12]
+ M_resultTruncated[11]=M_resultTruncated[11]
+ M_resultTruncated[10]=M_resultTruncated[10]
+ M_resultTruncated[9]=M_resultTruncated[9]
+ M_resultTruncated[8]=M_resultTruncated[8]
+ M_resultTruncated[7]=M_resultTruncated[7]
+ M_resultTruncated[6]=M_resultTruncated[6]
+ M_resultTruncated[5]=M_resultTruncated[5]
+ M_resultTruncated[4]=M_resultTruncated[4]
+ M_resultTruncated[3]=M_resultTruncated[3]
+ M_resultTruncated[2]=M_resultTruncated[2]
+ M_resultTruncated[1]=M_resultTruncated[1]
+ M_resultTruncated[0]=M_resultTruncated[0] M_multiplied=n_0_0 p_0[22]=n_0_23
+ p_0[21]=n_0_22 p_0[20]=n_0_21 p_0[19]=n_0_20 p_0[18]=n_0_19 p_0[17]=n_0_18
+ p_0[16]=n_0_17 p_0[15]=n_0_16 p_0[14]=n_0_15 p_0[13]=n_0_14 p_0[12]=n_0_13
+ p_0[11]=n_0_12 p_0[10]=n_0_11 p_0[9]=n_0_10 p_0[8]=n_0_9 p_0[7]=n_0_8
+ p_0[6]=n_0_7 p_0[5]=n_0_6 p_0[4]=n_0_5 p_0[3]=n_0_4 p_0[2]=n_0_3 p_0[1]=n_0_2
+ p_0[0]=n_0_1
Xmultiplier VM $PINS Res[63]=uc_0 Res[62]=uc_1 Res[61]=uc_2 Res[60]=uc_3
+ Res[59]=uc_4 Res[58]=uc_5 Res[57]=uc_6 Res[56]=uc_7 Res[55]=uc_8 Res[54]=uc_9
+ Res[53]=uc_10 Res[52]=uc_11 Res[51]=uc_12 Res[50]=uc_13 Res[49]=uc_14
+ Res[48]=uc_15 Res[47]=n_0_24 Res[46]=n_0_23 Res[45]=n_0_22 Res[44]=n_0_21
+ Res[43]=n_0_20 Res[42]=n_0_19 Res[41]=n_0_18 Res[40]=n_0_17 Res[39]=n_0_16
+ Res[38]=n_0_15 Res[37]=n_0_14 Res[36]=n_0_13 Res[35]=n_0_12 Res[34]=n_0_11
+ Res[33]=n_0_10 Res[32]=n_0_9 Res[31]=n_0_8 Res[30]=n_0_7 Res[29]=n_0_6
+ Res[28]=n_0_5 Res[27]=n_0_4 Res[26]=n_0_3 Res[25]=n_0_2 Res[24]=n_0_1
+ Res[23]=n_0_0 Res[22]=uc_16 Res[21]=uc_17 Res[20]=uc_18 Res[19]=uc_19
+ Res[18]=uc_20 Res[17]=uc_21 Res[16]=uc_22 Res[15]=uc_23 Res[14]=uc_24
+ Res[13]=uc_25 Res[12]=uc_26 Res[11]=uc_27 Res[10]=uc_28 Res[9]=uc_29
+ Res[8]=uc_30 Res[7]=uc_31 Res[6]=uc_32 Res[5]=uc_33 Res[4]=uc_34 Res[3]=uc_35
+ Res[2]=uc_36 Res[1]=uc_37 Res[0]=uc_38 clk_CTS_1_PP_4=CTS_n_tid1_90
+ clk_CTS_1_PP_5=CTS_n_tid1_91 A[31]=uc_39 A[30]=uc_40 A[29]=uc_41 A[28]=uc_42
+ A[27]=uc_43 A[26]=uc_44 A[25]=uc_45 A[24]=uc_46 A[23]=uc_47 A[22]=n_0_25
+ A[21]=n_0_26 A[20]=n_0_27 A[19]=n_0_28 A[18]=n_0_29 A[17]=n_0_30 A[16]=n_0_31
+ A[15]=n_0_32 A[14]=n_0_33 A[13]=n_0_34 A[12]=n_0_35 A[11]=n_0_36 A[10]=n_0_37
+ A[9]=n_0_38 A[8]=n_0_39 A[7]=n_0_40 A[6]=n_0_41 A[5]=n_0_42 A[4]=n_0_43
+ A[3]=n_0_44 A[2]=n_0_45 A[1]=n_0_46 A[0]=n_0_47 B[31]=uc_48 B[30]=uc_49
+ B[29]=uc_50 B[28]=uc_51 B[27]=uc_52 B[26]=uc_53 B[25]=uc_54 B[24]=uc_55
+ B[23]=uc_56 B[22]=n_0_48 B[21]=n_0_49 B[20]=n_0_50 B[19]=n_0_51 B[18]=n_0_52
+ B[17]=n_0_53 B[16]=n_0_54 B[15]=n_0_55 B[14]=n_0_56 B[13]=n_0_57 B[12]=n_0_58
+ B[11]=n_0_59 B[10]=n_0_60 B[9]=n_0_61 B[8]=n_0_62 B[7]=n_0_63 B[6]=n_0_64
+ B[5]=n_0_65 B[4]=n_0_66 B[3]=n_0_67 B[2]=n_0_68 B[1]=n_0_69 B[0]=n_0_70
+ enable=CLOCK_slh__n411 reset=reset clk_CTS_1_PP_6=clk
Xhfn_ipo_c10 CLKBUF_X3 $PINS Z=hfn_ipo_n10 A=n_0_1_112
Xhfn_ipo_c11 CLKBUF_X1 $PINS Z=hfn_ipo_n11 A=n_0_1_112
XCLOCK_slh__c78 CLKBUF_X1 $PINS Z=n_0_161 A=CLOCK_slh__n179
XCLOCK_slh__c77 CLKBUF_X1 $PINS Z=CLOCK_slh__n179 A=CLOCK_slh__n178
XCLOCK_slh__c81 CLKBUF_X1 $PINS Z=CLOCK_slh__n183 A=CLOCK_slh__n182
XCLOCK_slh__c82 CLKBUF_X1 $PINS Z=n_0_129 A=CLOCK_slh__n183
XCLOCK_slh__c85 CLKBUF_X1 $PINS Z=CLOCK_slh__n187 A=CLOCK_slh__n186
XCLOCK_slh__c86 CLKBUF_X1 $PINS Z=n_0_133 A=CLOCK_slh__n187
XCLOCK_slh__c89 CLKBUF_X1 $PINS Z=CLOCK_slh__n191 A=CLOCK_slh__n190
XCLOCK_slh__c90 CLKBUF_X1 $PINS Z=n_0_136 A=CLOCK_slh__n191
XCLOCK_slh__c93 CLKBUF_X1 $PINS Z=CLOCK_slh__n195 A=CLOCK_slh__n194
XCLOCK_slh__c94 CLKBUF_X1 $PINS Z=n_0_105 A=CLOCK_slh__n195
XCLOCK_slh__c97 CLKBUF_X1 $PINS Z=CLOCK_slh__n199 A=CLOCK_slh__n198
XCLOCK_slh__c98 CLKBUF_X1 $PINS Z=n_0_130 A=CLOCK_slh__n199
XCLOCK_slh__c101 CLKBUF_X1 $PINS Z=CLOCK_slh__n203 A=CLOCK_slh__n202
XCLOCK_slh__c102 CLKBUF_X1 $PINS Z=n_0_131 A=CLOCK_slh__n203
XCLOCK_slh__c105 CLKBUF_X1 $PINS Z=CLOCK_slh__n207 A=CLOCK_slh__n206
XCLOCK_slh__c106 CLKBUF_X1 $PINS Z=n_0_132 A=CLOCK_slh__n207
XCLOCK_slh__c109 CLKBUF_X1 $PINS Z=CLOCK_slh__n211 A=CLOCK_slh__n210
XCLOCK_slh__c110 CLKBUF_X1 $PINS Z=n_0_134 A=CLOCK_slh__n211
XCLOCK_slh__c113 CLKBUF_X1 $PINS Z=CLOCK_slh__n215 A=CLOCK_slh__n214
XCLOCK_slh__c114 CLKBUF_X1 $PINS Z=n_0_162 A=CLOCK_slh__n215
XCLOCK_slh__c117 CLKBUF_X1 $PINS Z=CLOCK_slh__n219 A=CLOCK_slh__n218
XCLOCK_slh__c118 CLKBUF_X1 $PINS Z=n_0_163 A=CLOCK_slh__n219
XCLOCK_slh__c121 CLKBUF_X1 $PINS Z=CLOCK_slh__n223 A=CLOCK_slh__n222
XCLOCK_slh__c122 CLKBUF_X1 $PINS Z=n_0_164 A=CLOCK_slh__n223
XCLOCK_slh__c125 CLKBUF_X1 $PINS Z=CLOCK_slh__n227 A=CLOCK_slh__n226
XCLOCK_slh__c126 CLKBUF_X1 $PINS Z=n_0_167 A=CLOCK_slh__n227
XCLOCK_slh__c129 CLKBUF_X1 $PINS Z=CLOCK_slh__n231 A=CLOCK_slh__n230
XCLOCK_slh__c130 CLKBUF_X1 $PINS Z=n_0_103 A=CLOCK_slh__n231
XCLOCK_slh__c133 CLKBUF_X1 $PINS Z=CLOCK_slh__n235 A=CLOCK_slh__n234
XCLOCK_slh__c134 CLKBUF_X1 $PINS Z=n_0_165 A=CLOCK_slh__n235
XCLOCK_slh__c137 CLKBUF_X1 $PINS Z=CLOCK_slh__n239 A=CLOCK_slh__n238
XCLOCK_slh__c138 CLKBUF_X1 $PINS Z=n_0_111 A=CLOCK_slh__n239
XCLOCK_slh__c141 CLKBUF_X1 $PINS Z=CLOCK_slh__n243 A=CLOCK_slh__n242
XCLOCK_slh__c142 CLKBUF_X1 $PINS Z=n_0_140 A=CLOCK_slh__n243
XCLOCK_slh__c145 CLKBUF_X1 $PINS Z=CLOCK_slh__n247 A=CLOCK_slh__n246
XCLOCK_slh__c146 CLKBUF_X1 $PINS Z=n_0_147 A=CLOCK_slh__n247
XCLOCK_slh__c149 CLKBUF_X1 $PINS Z=CLOCK_slh__n251 A=CLOCK_slh__n250
XCLOCK_slh__c150 CLKBUF_X1 $PINS Z=n_0_110 A=CLOCK_slh__n251
XCLOCK_slh__c153 CLKBUF_X1 $PINS Z=CLOCK_slh__n255 A=CLOCK_slh__n254
XCLOCK_slh__c154 CLKBUF_X1 $PINS Z=n_0_155 A=CLOCK_slh__n255
XCLOCK_slh__c157 CLKBUF_X1 $PINS Z=CLOCK_slh__n259 A=CLOCK_slh__n258
XCLOCK_slh__c158 CLKBUF_X1 $PINS Z=n_0_166 A=CLOCK_slh__n259
XCLOCK_slh__c161 CLKBUF_X1 $PINS Z=CLOCK_slh__n263 A=CLOCK_slh__n262
XCLOCK_slh__c162 CLKBUF_X1 $PINS Z=n_0_113 A=CLOCK_slh__n263
XCLOCK_slh__c165 CLKBUF_X1 $PINS Z=CLOCK_slh__n267 A=CLOCK_slh__n266
XCLOCK_slh__c166 CLKBUF_X1 $PINS Z=n_0_121 A=CLOCK_slh__n267
XCLOCK_slh__c169 CLKBUF_X1 $PINS Z=CLOCK_slh__n271 A=CLOCK_slh__n270
XCLOCK_slh__c170 CLKBUF_X1 $PINS Z=n_0_153 A=CLOCK_slh__n271
XCLOCK_slh__c173 CLKBUF_X1 $PINS Z=CLOCK_slh__n275 A=CLOCK_slh__n274
XCLOCK_slh__c174 CLKBUF_X1 $PINS Z=n_0_107 A=CLOCK_slh__n275
XCLOCK_slh__c177 CLKBUF_X1 $PINS Z=CLOCK_slh__n279 A=CLOCK_slh__n278
XCLOCK_slh__c178 CLKBUF_X1 $PINS Z=n_0_149 A=CLOCK_slh__n279
XCLOCK_slh__c181 CLKBUF_X1 $PINS Z=CLOCK_slh__n283 A=CLOCK_slh__n282
XCLOCK_slh__c182 CLKBUF_X1 $PINS Z=n_0_135 A=CLOCK_slh__n283
XCLOCK_slh__c185 CLKBUF_X1 $PINS Z=CLOCK_slh__n287 A=CLOCK_slh__n286
XCLOCK_slh__c186 CLKBUF_X1 $PINS Z=n_0_145 A=CLOCK_slh__n287
XCLOCK_slh__c189 CLKBUF_X1 $PINS Z=CLOCK_slh__n291 A=CLOCK_slh__n290
XCLOCK_slh__c190 CLKBUF_X1 $PINS Z=n_0_156 A=CLOCK_slh__n291
XCLOCK_slh__c193 CLKBUF_X1 $PINS Z=CLOCK_slh__n295 A=CLOCK_slh__n294
XCLOCK_slh__c194 CLKBUF_X1 $PINS Z=n_0_159 A=CLOCK_slh__n295
XCLOCK_slh__c197 CLKBUF_X1 $PINS Z=CLOCK_slh__n299 A=CLOCK_slh__n298
XCLOCK_slh__c198 CLKBUF_X1 $PINS Z=n_0_141 A=CLOCK_slh__n299
XCLOCK_slh__c201 CLKBUF_X1 $PINS Z=CLOCK_slh__n303 A=CLOCK_slh__n302
XCLOCK_slh__c202 CLKBUF_X1 $PINS Z=n_0_142 A=CLOCK_slh__n303
XCLOCK_slh__c205 CLKBUF_X1 $PINS Z=CLOCK_slh__n307 A=CLOCK_slh__n306
XCLOCK_slh__c206 CLKBUF_X1 $PINS Z=n_0_125 A=CLOCK_slh__n307
XCLOCK_slh__c209 CLKBUF_X1 $PINS Z=CLOCK_slh__n311 A=CLOCK_slh__n310
XCLOCK_slh__c210 CLKBUF_X1 $PINS Z=n_0_126 A=CLOCK_slh__n311
XCLOCK_slh__c213 CLKBUF_X1 $PINS Z=CLOCK_slh__n315 A=CLOCK_slh__n314
XCLOCK_slh__c214 CLKBUF_X1 $PINS Z=n_0_158 A=CLOCK_slh__n315
XCLOCK_slh__c217 CLKBUF_X1 $PINS Z=CLOCK_slh__n319 A=CLOCK_slh__n318
XCLOCK_slh__c218 CLKBUF_X1 $PINS Z=n_0_139 A=CLOCK_slh__n319
XCLOCK_slh__c221 CLKBUF_X1 $PINS Z=CLOCK_slh__n323 A=CLOCK_slh__n322
XCLOCK_slh__c222 CLKBUF_X1 $PINS Z=n_0_157 A=CLOCK_slh__n323
XCLOCK_slh__c225 CLKBUF_X1 $PINS Z=CLOCK_slh__n327 A=CLOCK_slh__n326
XCLOCK_slh__c226 CLKBUF_X1 $PINS Z=n_0_144 A=CLOCK_slh__n327
XCLOCK_slh__c229 CLKBUF_X1 $PINS Z=CLOCK_slh__n331 A=CLOCK_slh__n330
XCLOCK_slh__c230 CLKBUF_X1 $PINS Z=n_0_146 A=CLOCK_slh__n331
XCLOCK_slh__c233 CLKBUF_X1 $PINS Z=CLOCK_slh__n335 A=CLOCK_slh__n334
XCLOCK_slh__c234 CLKBUF_X1 $PINS Z=n_0_138 A=CLOCK_slh__n335
XCLOCK_slh__c237 CLKBUF_X1 $PINS Z=CLOCK_slh__n339 A=CLOCK_slh__n338
XCLOCK_slh__c238 CLKBUF_X1 $PINS Z=n_0_127 A=CLOCK_slh__n339
XCLOCK_slh__c241 CLKBUF_X1 $PINS Z=CLOCK_slh__n343 A=CLOCK_slh__n342
XCLOCK_slh__c242 CLKBUF_X1 $PINS Z=n_0_151 A=CLOCK_slh__n343
XCLOCK_slh__c245 CLKBUF_X1 $PINS Z=CLOCK_slh__n347 A=CLOCK_slh__n346
XCLOCK_slh__c246 CLKBUF_X1 $PINS Z=n_0_123 A=CLOCK_slh__n347
XCLOCK_slh__c249 CLKBUF_X1 $PINS Z=CLOCK_slh__n351 A=CLOCK_slh__n350
XCLOCK_slh__c250 CLKBUF_X1 $PINS Z=n_0_152 A=CLOCK_slh__n351
XCLOCK_slh__c253 CLKBUF_X1 $PINS Z=CLOCK_slh__n355 A=CLOCK_slh__n354
XCLOCK_slh__c254 CLKBUF_X1 $PINS Z=n_0_150 A=CLOCK_slh__n355
XCLOCK_slh__c257 CLKBUF_X1 $PINS Z=CLOCK_slh__n359 A=CLOCK_slh__n358
XCLOCK_slh__c258 CLKBUF_X1 $PINS Z=n_0_154 A=CLOCK_slh__n359
XCLOCK_slh__c261 CLKBUF_X1 $PINS Z=CLOCK_slh__n363 A=CLOCK_slh__n362
XCLOCK_slh__c262 CLKBUF_X1 $PINS Z=n_0_108 A=CLOCK_slh__n363
XCLOCK_slh__c265 CLKBUF_X1 $PINS Z=CLOCK_slh__n367 A=CLOCK_slh__n366
XCLOCK_slh__c266 CLKBUF_X1 $PINS Z=n_0_109 A=CLOCK_slh__n367
XCLOCK_slh__c269 CLKBUF_X1 $PINS Z=CLOCK_slh__n371 A=CLOCK_slh__n370
XCLOCK_slh__c270 CLKBUF_X1 $PINS Z=n_0_137 A=CLOCK_slh__n371
XCLOCK_slh__c273 CLKBUF_X1 $PINS Z=CLOCK_slh__n375 A=CLOCK_slh__n374
XCLOCK_slh__c274 CLKBUF_X1 $PINS Z=n_0_143 A=CLOCK_slh__n375
XCLOCK_slh__c277 CLKBUF_X1 $PINS Z=CLOCK_slh__n379 A=CLOCK_slh__n378
XCLOCK_slh__c278 CLKBUF_X1 $PINS Z=n_0_160 A=CLOCK_slh__n379
XCLOCK_slh__c281 CLKBUF_X1 $PINS Z=CLOCK_slh__n383 A=CLOCK_slh__n382
XCLOCK_slh__c282 CLKBUF_X1 $PINS Z=n_0_148 A=CLOCK_slh__n383
XCLOCK_slh__c285 CLKBUF_X1 $PINS Z=CLOCK_slh__n387 A=CLOCK_slh__n386
XCLOCK_slh__c286 CLKBUF_X1 $PINS Z=n_0_112 A=CLOCK_slh__n387
XCLOCK_slh__c287 CLKBUF_X1 $PINS Z=CLOCK_slh__n389 A=CLOCK_slh__n388
XCLOCK_slh__c288 CLKBUF_X1 $PINS Z=n_0_128 A=CLOCK_slh__n389
XCLOCK_slh__c289 CLKBUF_X1 $PINS Z=CLOCK_slh__n391 A=CLOCK_slh__n390
XCLOCK_slh__c290 CLKBUF_X1 $PINS Z=n_0_106 A=CLOCK_slh__n391
XCLOCK_slh__c291 CLKBUF_X1 $PINS Z=CLOCK_slh__n393 A=CLOCK_slh__n392
XCLOCK_slh__c292 CLKBUF_X1 $PINS Z=n_0_119 A=CLOCK_slh__n393
XCLOCK_slh__c293 CLKBUF_X1 $PINS Z=CLOCK_slh__n395 A=CLOCK_slh__n394
XCLOCK_slh__c294 CLKBUF_X1 $PINS Z=n_0_124 A=CLOCK_slh__n395
XCLOCK_slh__c295 CLKBUF_X1 $PINS Z=CLOCK_slh__n397 A=CLOCK_slh__n396
XCLOCK_slh__c296 CLKBUF_X1 $PINS Z=n_0_120 A=CLOCK_slh__n397
XCLOCK_slh__c297 CLKBUF_X1 $PINS Z=CLOCK_slh__n399 A=CLOCK_slh__n398
XCLOCK_slh__c298 CLKBUF_X1 $PINS Z=n_0_122 A=CLOCK_slh__n399
XCLOCK_slh__c299 CLKBUF_X1 $PINS Z=CLOCK_slh__n401 A=CLOCK_slh__n400
XCLOCK_slh__c300 CLKBUF_X1 $PINS Z=n_0_114 A=CLOCK_slh__n401
XCLOCK_slh__c301 CLKBUF_X1 $PINS Z=CLOCK_slh__n403 A=CLOCK_slh__n402
XCLOCK_slh__c302 CLKBUF_X1 $PINS Z=n_0_115 A=CLOCK_slh__n403
XCLOCK_slh__c303 CLKBUF_X1 $PINS Z=CLOCK_slh__n405 A=CLOCK_slh__n404
XCLOCK_slh__c304 CLKBUF_X1 $PINS Z=n_0_116 A=CLOCK_slh__n405
XCLOCK_slh__c305 CLKBUF_X1 $PINS Z=CLOCK_slh__n407 A=CLOCK_slh__n406
XCLOCK_slh__c306 CLKBUF_X1 $PINS Z=n_0_117 A=CLOCK_slh__n407
XCLOCK_slh__c307 CLKBUF_X1 $PINS Z=CLOCK_slh__n409 A=CLOCK_slh__n408
XCLOCK_slh__c308 CLKBUF_X1 $PINS Z=n_0_118 A=CLOCK_slh__n409
XCLOCK_slh__c309 CLKBUF_X1 $PINS Z=CLOCK_slh__n412 A=enable
XCLOCK_slh__c310 CLKBUF_X1 $PINS Z=CLOCK_slh__n413 A=CLOCK_slh__n412
XCLOCK_slh__c311 CLKBUF_X1 $PINS Z=CLOCK_slh__n414 A=CLOCK_slh__n413
XCLOCK_slh__c312 CLKBUF_X1 $PINS Z=CLOCK_slh__n420 A=CLOCK_slh__n414
XCLOCK_slh__c318 CLKBUF_X1 $PINS Z=CLOCK_slh__n421 A=CLOCK_slh__n420
XCLOCK_slh__c319 CLKBUF_X1 $PINS Z=CLOCK_slh__n422 A=CLOCK_slh__n421
XCLOCK_slh__c320 CLKBUF_X1 $PINS Z=CLOCK_slh__n428 A=CLOCK_slh__n422
XCLOCK_slh__c326 CLKBUF_X1 $PINS Z=CLOCK_slh__n429 A=CLOCK_slh__n428
XCLOCK_slh__c327 CLKBUF_X1 $PINS Z=CLOCK_slh__n430 A=CLOCK_slh__n429
XCLOCK_slh__c328 CLKBUF_X1 $PINS Z=CLOCK_slh__n436 A=CLOCK_slh__n430
XCLOCK_slh__c334 CLKBUF_X1 $PINS Z=CLOCK_slh__n437 A=CLOCK_slh__n436
XCLOCK_slh__c335 CLKBUF_X1 $PINS Z=CLOCK_slh__n438 A=CLOCK_slh__n437
XCLOCK_slh__c336 CLKBUF_X1 $PINS Z=CLOCK_slh__n444 A=CLOCK_slh__n438
XCLOCK_slh__c342 CLKBUF_X1 $PINS Z=CLOCK_slh__n445 A=CLOCK_slh__n444
XCLOCK_slh__c343 CLKBUF_X1 $PINS Z=CLOCK_slh__n446 A=CLOCK_slh__n445
XCLOCK_slh__c344 CLKBUF_X1 $PINS Z=CLOCK_slh__n450 A=CLOCK_slh__n446
XCLOCK_slh__c348 CLKBUF_X1 $PINS Z=CLOCK_slh__n451 A=CLOCK_slh__n450
XCLOCK_slh__c349 CLKBUF_X1 $PINS Z=CLOCK_slh__n452 A=CLOCK_slh__n451
XCLOCK_slh__c350 CLKBUF_X1 $PINS Z=CLOCK_slh__n456 A=CLOCK_slh__n452
XCLOCK_slh__c354 CLKBUF_X1 $PINS Z=CLOCK_slh__n457 A=CLOCK_slh__n456
XCLOCK_slh__c355 CLKBUF_X1 $PINS Z=CLOCK_slh__n458 A=CLOCK_slh__n457
XCLOCK_slh__c356 CLKBUF_X1 $PINS Z=CLOCK_slh__n462 A=CLOCK_slh__n458
XCLOCK_slh__c360 CLKBUF_X1 $PINS Z=CLOCK_slh__n463 A=CLOCK_slh__n462
XCLOCK_slh__c361 CLKBUF_X1 $PINS Z=CLOCK_slh__n464 A=CLOCK_slh__n463
XCLOCK_slh__c362 CLKBUF_X1 $PINS Z=CLOCK_slh__n468 A=CLOCK_slh__n464
XCLOCK_slh__c366 CLKBUF_X1 $PINS Z=CLOCK_slh__n469 A=CLOCK_slh__n468
XCLOCK_slh__c367 CLKBUF_X1 $PINS Z=CLOCK_slh__n470 A=CLOCK_slh__n469
XCLOCK_slh__c368 CLKBUF_X1 $PINS Z=CLOCK_slh__n411 A=CLOCK_slh__n470
.ENDS
